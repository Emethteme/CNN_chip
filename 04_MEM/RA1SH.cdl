*
* Copyright 2016 by Artisan Components, Inc.
* This file has been provided pursuant to a License Agreement
* containing restrictions on its use.  This file contains valuable
* trade secrets and proprietary information of Artisan Components,
* Inc. and is protected by law.
*
** generated by bif2cdl v3.0f **
** Generator version 2001Q4V0 **
*
** begin lvs.header
** end lvs.header
*.SCALE meter
*.BIPOLAR
*.DIOAREA
*.DIOPERI
.GLOBAL VSS VDD
*
****
.SUBCKT RA1SHCCMWG BL BL_ MWLB MWLT MWPB MWPT
** RA1SHCCMWG: 8 flat devices **
m1 BL MWPB CORED VSS N L=0.235U W=0.21U
m2 BL_ MWPB CORED_ VSS N L=0.235U W=0.21U
m3 BL MWPT CORED VSS N L=0.235U W=0.21U
m4 BL_ MWPT CORED_ VSS N L=0.235U W=0.21U
m5 VSS VSS CORED VSS N L=0.18U W=0.42U
m6 VSS VSS CORED_ VSS N L=0.18U W=0.42U
m7 VSS VSS CORED VSS N L=0.18U W=0.42U
m8 VSS VSS CORED_ VSS N L=0.18U W=0.42U
.ENDS RA1SHCCMWG
****
.SUBCKT RA1SHCCG BL BL_ WL WP
** RA1SHCCG: 6 flat devices **
m1 BL WP CORED VSS N L=0.235U W=0.21U
m2 BL_ WP CORED_ VSS N L=0.235U W=0.21U
m3 CORED_ CORED VDD VDD P L=0.18U W=0.22U
m4 CORED_ CORED VSS VSS N L=0.18U W=0.42U
m5 CORED CORED_ VDD VDD P L=0.18U W=0.22U
m6 CORED CORED_ VSS VSS N L=0.18U W=0.42U
.ENDS RA1SHCCG
****
.SUBCKT RA1SHLEFT_CAP A0 A0_ GTP GTP_0 GTP_1 OE_ STUBDR STUBDR_ STUBDW STUBDW_
+  WE WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12
+  WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24
+  WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3
** RA1SHLEFT_CAP: 206 flat devices **
XI0_10 VDD VDD WL_23 WL_23 RA1SHCCG
XI0_11 VDD VDD WL_22 WL_22 RA1SHCCG
XI0_12 VDD VDD WL_21 WL_21 RA1SHCCG
XI0_13 VDD VDD WL_20 WL_20 RA1SHCCG
XI0_14 VDD VDD WL_19 WL_19 RA1SHCCG
XI0_15 VDD VDD WL_18 WL_18 RA1SHCCG
XI0_16 VDD VDD WL_17 WL_17 RA1SHCCG
XI0_17 VDD VDD WL_16 WL_16 RA1SHCCG
XI0_18 VDD VDD WL_15 WL_15 RA1SHCCG
XI0_19 VDD VDD WL_14 WL_14 RA1SHCCG
XI0_20 VDD VDD WL_13 WL_13 RA1SHCCG
XI0_21 VDD VDD WL_12 WL_12 RA1SHCCG
XI0_22 VDD VDD WL_11 WL_11 RA1SHCCG
XI0_23 VDD VDD WL_10 WL_10 RA1SHCCG
XI0_24 VDD VDD WL_9 WL_9 RA1SHCCG
XI0_25 VDD VDD WL_8 WL_8 RA1SHCCG
XI0_26 VDD VDD WL_7 WL_7 RA1SHCCG
XI0_27 VDD VDD WL_6 WL_6 RA1SHCCG
XI0_28 VDD VDD WL_5 WL_5 RA1SHCCG
XI0_29 VDD VDD WL_4 WL_4 RA1SHCCG
XI0_3 VDD VDD WL_30 WL_30 RA1SHCCG
XI0_30 VDD VDD WL_3 WL_3 RA1SHCCG
XI0_31 VDD VDD WL_2 WL_2 RA1SHCCG
XI0_32 VDD VDD WL_1 WL_1 RA1SHCCG
XI0_33 VDD VDD WL_0 WL_0 RA1SHCCG
XI0_34 VDD VDD WL WL RA1SHCCG
XI0_35 VDD VDD VSS VSS VSS VSS RA1SHCCMWG
XI0_37 VDD VDD VSS VSS RA1SHCCG
XI0_4 VDD VDD WL_29 WL_29 RA1SHCCG
XI0_5 VDD VDD WL_28 WL_28 RA1SHCCG
XI0_6 VDD VDD WL_27 WL_27 RA1SHCCG
XI0_7 VDD VDD WL_26 WL_26 RA1SHCCG
XI0_8 VDD VDD WL_25 WL_25 RA1SHCCG
XI0_9 VDD VDD WL_24 WL_24 RA1SHCCG
.ENDS RA1SHLEFT_CAP
****
.SUBCKT RA1SHFLIO OE_ TCLK WE
** RA1SHFLIO: 3 flat devices **
d1 VSS TCLK DN 0.36P 2.4U
d2 VSS OE_ DN 0.36P 2.4U
d3 VSS WE DN 0.36P 2.4U
.ENDS RA1SHFLIO
****
.SUBCKT RA1SHFLSA GTP
** RA1SHFLSA: 1 flat devices **
d1 VSS GTP DN 0.36P 2.4U
.ENDS RA1SHFLSA
****
.SUBCKT RA1SHIO8 D DI_ DPN DPU DW DW_ D_ GTP OE_ Q QI SP UTIDMX WE
** RA1SHIO8: 59 flat devices **
d47 VSS D DN 0.36P 2.4U
d58 VSS D DN 0.36P 2.4U
d59 VSS Q DN 0.36P 2.4U
m1 QI DPU VSS VSS N L=0.18U W=3.46U
m10 QPD OEI_ VSS VSS N L=0.18U W=0.72U
m11 QIL QI VDD VDD P L=0.18U W=1.3U
m12 QIL QI VSS VSS N L=0.18U W=0.72U
m13 SPN SP VDD VDD P L=0.18U W=0.46U
m14 SPN SP VSS VSS N L=0.18U W=0.3U
m15 DWPD GTPND DWI VSS N L=0.18U W=0.62U
m16 DWPD DW VDD VDD P L=0.28U W=0.24U
m17 DWPD DW VSS VSS N L=0.54U W=0.24U
m18 DWPD GTP DWI VDD P L=0.18U W=0.78U
m19 DW_PU GTPND DNWI VSS N L=0.18U W=0.62U
m2 QI DPN VDD VDD P L=0.18U W=9.38U
m20 DW_PU GTP DNWI VDD P L=0.18U W=0.78U
m21 GTPND GTP VDD VDD P L=0.18U W=0.44U
m22 GTPND GTP VSS VSS N L=0.18U W=0.3U
m23 DI DI_ VDD VDD P L=0.18U W=1.6U
m24 DI DI_ VSS VSS N L=0.18U W=0.76U
m25 DB DI VDD VDD P L=0.18U W=1.08U
m26 DB DI VSS VSS N L=0.18U W=0.52U
m27 WEI N53 VDD VDD P L=0.18U W=1.3U
m28 WEI N53 VSS VSS N L=0.18U W=0.74U
m29 OEI OEI_ VDD VDD P L=0.18U W=1.26U
m3 Q QPU VDD VDD P L=0.18U W=10.8U
m30 OEI OEI_ VSS VSS N L=0.18U W=0.64U
m31 QI SP N77 VDD P L=0.18U W=2U
m32 N77 QIL VDD VDD P L=0.18U W=2U
m33 QI SPN N76 VSS N L=0.18U W=2U
m34 N76 QIL VSS VSS N L=0.18U W=2U
m35 N36 OE_ VDD VDD P L=0.18U W=0.84U
m36 N36 OE_ VSS VSS N L=0.18U W=0.42U
m37 N53 WE VDD VDD P L=0.18U W=0.5U
m38 N53 WE VSS VSS N L=0.18U W=0.24U
m39 DWI WEI VDD VDD P L=0.18U W=1.54U
m4 Q QPD VSS VSS N L=0.18U W=7.2U
m40 N78 WEI VSS VSS N L=0.18U W=1.34U
m41 DWI DI VDD VDD P L=0.18U W=1.54U
m42 DWI DI N78 VSS N L=0.18U W=1.34U
m43 DNWI WEI VDD VDD P L=0.18U W=1.54U
m44 N79 WEI VSS VSS N L=0.18U W=1.34U
m45 DNWI DB VDD VDD P L=0.18U W=1.54U
m46 DNWI DB N79 VSS N L=0.18U W=1.34U
m48 D_ D VDD VDD P L=0.18U W=0.62U
m49 D_ D VSS VSS N L=0.18U W=0.3U
m5 OEI_ N36 VDD VDD P L=0.18U W=2.3U
m50 QPU OEI_ QI VDD P L=0.18U W=0.34U
m51 QPD OEI QI VSS N L=0.18U W=0.66U
m52 DW DWPD VDD VDD P L=0.18U W=5.18U
m53 DW DWPD VSS VSS N L=0.18U W=2.48U
m54 DW_PU DW_ VDD VDD P L=0.28U W=0.24U
m55 DW_PU DW_ VSS VSS N L=0.54U W=0.24U
m56 DW_ DW_PU VDD VDD P L=0.18U W=5.18U
m57 DW_ DW_PU VSS VSS N L=0.18U W=2.48U
m6 OEI_ N36 VSS VSS N L=0.18U W=1.14U
m7 QPD OEI_ QI VDD P L=0.18U W=7.12U
m8 QPU OEI QI VSS N L=0.18U W=3.24U
m9 QPU OEI VDD VDD P L=0.18U W=1.78U
.ENDS RA1SHIO8
****
.SUBCKT RA1SHIOX D DI_ DPN DPU DW DW_ GTP IO IO_1 OE_ Q QI SP WE
** RA1SHIOX: 59 flat devices **
XI0_0 D DI_ DPN DPU DW DW_ DI_ GTP OE_ Q QI SP VSS WE RA1SHIO8
.ENDS RA1SHIOX
****
.SUBCKT RA1SHCD A0 A0_ BL0 BL0_ BL1 BL1_ DR DRSA DR_ DW DWSA DW_ G0 G1 GTP
+  STUBDR STUBDR_ STUBDW STUBDW_ YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2
+  YP1_3
** RA1SHCD: 43 flat devices **
m1 BL0_ CS0 DR_ VDD P L=0.2U W=3.51U
m10 BL1_ BL1PD VSS VSS N L=0.18U W=6.28U
m11 BL1_PD CS1 DW_ VDD P L=0.18U W=1.48U
m12 BL1_PD CS1 VSS VSS N L=0.18U W=0.74U
m13 BL1_ CS1 DR_ VDD P L=0.2U W=3.51U
m14 BL1PD CS1 DW VDD P L=0.18U W=1.48U
m15 BL1PD CS1 VSS VSS N L=0.18U W=0.74U
m16 BL1 BL1_PD VSS VSS N L=0.18U W=6.28U
m17 BL0_ YI VDD VDD P L=0.18U W=10.86U
m18 BL0 YI VDD VDD P L=0.18U W=10.86U
m19 BL0 YI BL0_ VDD P L=0.18U W=10.86U
m2 BL0 BL0PD VSS VSS N L=0.18U W=6.28U
m20 BL1 YI VDD VDD P L=0.18U W=10.86U
m21 BL1_ YI VDD VDD P L=0.18U W=10.86U
m22 BL1_ YI BL1 VDD P L=0.18U W=10.86U
m23 CS0 A0_ VDD VDD P L=0.18U W=1.82U
m24 N65 A0_ VSS VSS N L=0.18U W=1.8U
m25 CS0 YI VDD VDD P L=0.18U W=1.82U
m26 CS0 YI N65 VSS N L=0.18U W=1.8U
m27 CS1 A0 VDD VDD P L=0.18U W=1.82U
m28 N66 A0 VSS VSS N L=0.18U W=1.8U
m29 CS1 YI VDD VDD P L=0.18U W=1.82U
m3 BL0_PD CS0 DW VDD P L=0.18U W=1.48U
m30 CS1 YI N66 VSS N L=0.18U W=1.8U
m31 YCDSEL_ G0 VDD VDD P L=0.18U W=0.8U
m32 N67 G0 VSS VSS N L=0.18U W=0.74U
m33 YCDSEL_ G1 VDD VDD P L=0.18U W=0.8U
m34 YCDSEL_ G1 N67 VSS N L=0.18U W=0.74U
m35 YCDSEL YCDSEL_ VDD VDD P L=0.18U W=0.52U
m36 YCDSEL YCDSEL_ VSS VSS N L=0.18U W=0.24U
m37 N37 YCDSEL_ GTP VDD P L=0.18U W=1.2U
m38 N37 YCDSEL_ VSS VSS N L=0.18U W=1U
m39 YI WL1_EN_ VDD VDD P L=0.18U W=12.4U
m4 BL0_PD CS0 VSS VSS N L=0.18U W=0.74U
m40 YI WL1_EN_ VSS VSS N L=0.18U W=7.24U
m41 WL1_EN_ N37 VDD VDD P L=0.18U W=6.06U
m42 WL1_EN_ N37 VSS VSS N L=0.18U W=3.8U
m43 N37 YCDSEL GTP VSS N L=0.18U W=0.88U
m5 BL0 CS0 DR VDD P L=0.2U W=3.55U
m6 BL0PD CS0 DW_ VDD P L=0.18U W=1.48U
m7 BL0PD CS0 VSS VSS N L=0.18U W=0.74U
m8 BL0_ BL0_PD VSS VSS N L=0.18U W=6.28U
m9 BL1 CS1 DR VDD P L=0.2U W=3.55U
.ENDS RA1SHCD
****
.SUBCKT RA1SHCDX A0 A0_ BL0 BL0_ BL1 BL1_ DRSA DWSA G0 G1 GTP STUBDR STUBDR_
+  STUBDW STUBDW_ YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3
** RA1SHCDX: 43 flat devices **
XI0_0 A0 A0_ BL0 BL0_ BL1 BL1_ STUBDR DRSA STUBDR_ STUBDW DWSA STUBDW_ G0 G1
+  GTP STUBDR STUBDR_ STUBDW STUBDW_ YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2
+  YP1_3 RA1SHCD
.ENDS RA1SHCDX
****
.SUBCKT RA1SHMUX_CD_ODD A0 A0_ BL0 BL0_ BL0_0 BL0_1 BL0_2 BL0_3 BL0_4 BL0_5
+  BL0_6 BL0__0 BL0__1 BL0__2 BL0__3 BL0__4 BL0__5 BL0__6 BL1 BL1_ BL1_0 BL1_1
+  BL1_2 BL1_3 BL1_4 BL1_5 BL1_6 BL1__0 BL1__1 BL1__2 BL1__3 BL1__4 BL1__5
+  BL1__6 DRSA DRSA_0 DRSA_1 DRSA_2 DRSA_3 DRSA_4 DRSA_5 DRSA_6 DWSA DWSA_0
+  DWSA_2 DWSA_3 DWSA_4 DWSA_5 DWSA_6 GTP STUBDR_0 STUBDR__0 STUBDW STUBDW_0
+  STUBDW__0 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3
** RA1SHMUX_CD_ODD: 344 flat devices **
XI0_0 A0 A0_ BL0_6 BL0__6 BL1_6 BL1__6 DRSA_1 DRSA_6 DRSA_0 STUBDW DWSA_6
+  DWSA_0 VDD YP1_3 GTP STUBDR_0 STUBDR__0 STUBDW_0 STUBDW__0 YP0_0 YP0_1
+  YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 RA1SHCD
XI1_0 A0 A0_ BL0_5 BL0__5 BL1_5 BL1__5 DRSA_5 DWSA_5 VDD YP1_2 GTP DRSA_1
+  DRSA_0 STUBDW DWSA_0 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3
+  RA1SHCDX
XI2_0 A0 A0_ BL0_4 BL0__4 BL1_4 BL1__4 DRSA_4 DWSA_4 VDD YP1_1 GTP DRSA_1
+  DRSA_0 STUBDW DWSA_0 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3
+  RA1SHCDX
XI3_0 A0 A0_ BL0_3 BL0__3 BL1_3 BL1__3 DRSA_3 DWSA_3 VDD YP1_0 GTP DRSA_1
+  DRSA_0 STUBDW DWSA_0 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3
+  RA1SHCDX
XI4_0 A0 A0_ BL0_2 BL0__2 BL1_2 BL1__2 DRSA_2 DWSA_2 YP0_3 VDD GTP DRSA_1
+  DRSA_0 STUBDW DWSA_0 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3
+  RA1SHCDX
XI5_0 A0 A0_ BL0_1 BL0__1 BL1_1 BL1__1 DRSA_1 STUBDW YP0_2 VDD GTP DRSA_1
+  DRSA_0 STUBDW DWSA_0 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3
+  RA1SHCDX
XI6_0 A0 A0_ BL0_0 BL0__0 BL1_0 BL1__0 DRSA_0 DWSA_0 YP0_1 VDD GTP DRSA_1
+  DRSA_0 STUBDW DWSA_0 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3
+  RA1SHCDX
XI7_0 A0 A0_ BL0 BL0_ BL1 BL1_ DRSA DWSA YP0_0 VDD GTP DRSA_1 DRSA_0 STUBDW
+  DWSA_0 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 RA1SHCDX
.ENDS RA1SHMUX_CD_ODD
****
.SUBCKT RA1SHSA8 DPN DPU DR DR_ DW DW_ GTP SP
** RA1SHSA8: 41 flat devices **
m1 N22 SRCD VSS VSS N L=0.18U W=1.58U
m10 DPN SDN VDD VDD P L=0.18U W=1.7U
m11 DPN SDN VSS VSS N L=0.18U W=3.1U
m12 SP SPN VDD VDD P L=0.18U W=2.12U
m13 SP SPN VSS VSS N L=0.18U W=1.38U
m14 GTPN GTP VDD VDD P L=0.18U W=0.82U
m15 GTPN GTP VSS VSS N L=0.18U W=0.34U
m16 ND1 GTPN VDD VDD P L=0.18U W=0.64U
m17 ND1 GTPN VSS VSS N L=0.18U W=0.36U
m18 ND2 ND1 VDD VDD P L=0.18U W=1.82U
m19 ND2 ND1 VSS VSS N L=0.18U W=0.76U
m2 SD SP DR VDD P L=0.19U W=3.1U
m20 N40 DRP VSS VSS N L=0.18U W=1.3U
m21 SPN GTPN N40 VSS N L=0.18U W=0.88U
m22 SPN DRP VDD VDD P L=0.18U W=1.2U
m23 SPN GTPN VDD VDD P L=0.18U W=0.72U
m24 DRP ND2 VDD VDD P L=0.18U W=3.28U
m25 DRP ND2 VSS VSS N L=0.18U W=2.14U
m26 DR_ DRP VDD VDD P L=0.18U W=3.9U
m27 DR DRP VDD VDD P L=0.18U W=3.9U
m28 DR DRP DR_ VDD P L=0.18U W=5U
m29 SD_ SD SRC VSS N L=0.26U W=3.9U
m3 SD_ SP DR_ VDD P L=0.19U W=3.1U
m30 SD SD_ SRC VSS N L=0.26U W=3.9U
m31 SD_ SD SRC VSS N L=0.26U W=3.15U
m32 SD SD_ SRC VSS N L=0.26U W=3.15U
m33 SRC GTPN N22 VSS N L=0.18U W=1.74U
m34 SRCD SRCPU VDD VDD P L=0.18U W=0.68U
m35 SRCD SRCPU VSS VSS N L=0.18U W=0.48U
m36 SRCPU DRP VDD VDD P L=0.18U W=1.36U
m37 SRCPU DRP VSS VSS N L=0.18U W=0.48U
m38 VDD SRCPU SRC VSS N L=0.18U W=1.76U
m39 SD SRCD SD_ VDD P L=0.18U W=1.24U
m4 SD_ SD VDD VDD P L=0.18U W=1.24U
m40 SRC GTPN N52 VSS N L=0.18U W=1.74U
m41 N52 SRCD VSS VSS N L=0.18U W=1.58U
m5 SD SD_ VDD VDD P L=0.18U W=1.24U
m6 SDN SD VDD VDD P L=0.18U W=1.8U
m7 SDN SD VSS VSS N L=0.18U W=0.62U
m8 DPU SD_ VDD VDD P L=0.18U W=1.8U
m9 DPU SD_ VSS VSS N L=0.18U W=0.62U
.ENDS RA1SHSA8
****
.SUBCKT RA1SHCCP BL BL_ WL WP
** RA1SHCCP: 6 flat devices **
m1 BL WP CORED VSS N L=0.235U W=0.21U
m2 BL_ WP CORED_ VSS N L=0.235U W=0.21U
m3 CORED_ CORED VDD VDD P L=0.18U W=0.22U
m4 CORED_ CORED VSS VSS N L=0.18U W=0.42U
m5 CORED CORED_ VDD VDD P L=0.18U W=0.22U
m6 CORED CORED_ VSS VSS N L=0.18U W=0.42U
.ENDS RA1SHCCP
****
.SUBCKT RA1SHBIT_MUX_1 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8
+  BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5
+  BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL WP
** RA1SHBIT_MUX_1: 96 flat devices **
XI0_0 BL_14 BL__14 WL WP RA1SHCCG
XI10_0 BL_4 BL__4 WL WP RA1SHCCP
XI11_0 BL_3 BL__3 WL WP RA1SHCCG
XI12_0 BL_2 BL__2 WL WP RA1SHCCG
XI13_0 BL_1 BL__1 WL WP RA1SHCCP
XI14_0 BL_0 BL__0 WL WP RA1SHCCP
XI15_0 BL BL_ WL WP RA1SHCCG
XI1_0 BL_13 BL__13 WL WP RA1SHCCP
XI2_0 BL_12 BL__12 WL WP RA1SHCCP
XI3_0 BL_11 BL__11 WL WP RA1SHCCG
XI4_0 BL_10 BL__10 WL WP RA1SHCCG
XI5_0 BL_9 BL__9 WL WP RA1SHCCP
XI6_0 BL_8 BL__8 WL WP RA1SHCCP
XI7_0 BL_7 BL__7 WL WP RA1SHCCG
XI8_0 BL_6 BL__6 WL WP RA1SHCCG
XI9_0 BL_5 BL__5 WL WP RA1SHCCP
.ENDS RA1SHBIT_MUX_1
****
.SUBCKT RA1SHBIT_MUX_0 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8
+  BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5
+  BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL WP
** RA1SHBIT_MUX_0: 96 flat devices **
XI0_0 BL_14 BL__14 WL WP RA1SHCCG
XI10_0 BL_4 BL__4 WL WP RA1SHCCP
XI11_0 BL_3 BL__3 WL WP RA1SHCCG
XI12_0 BL_2 BL__2 WL WP RA1SHCCG
XI13_0 BL_1 BL__1 WL WP RA1SHCCP
XI14_0 BL_0 BL__0 WL WP RA1SHCCP
XI15_0 BL BL_ WL WP RA1SHCCG
XI1_0 BL_13 BL__13 WL WP RA1SHCCP
XI2_0 BL_12 BL__12 WL WP RA1SHCCP
XI3_0 BL_11 BL__11 WL WP RA1SHCCG
XI4_0 BL_10 BL__10 WL WP RA1SHCCG
XI5_0 BL_9 BL__9 WL WP RA1SHCCP
XI6_0 BL_8 BL__8 WL WP RA1SHCCP
XI7_0 BL_7 BL__7 WL WP RA1SHCCG
XI8_0 BL_6 BL__6 WL WP RA1SHCCG
XI9_0 BL_5 BL__5 WL WP RA1SHCCP
.ENDS RA1SHBIT_MUX_0
****
.SUBCKT RA1SHBIT_COL BL BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9
+  BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21
+  BL_22 BL_23 BL_24 BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 WL WL_0 WL_1 WL_2
+  WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15
+  WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27
+  WL_28 WL_29 WL_30 WP WP_0 WP_1 WP_2 WP_3 WP_4 WP_5 WP_6 WP_7 WP_8 WP_9
+  WP_10 WP_11 WP_12 WP_13 WP_14 WP_15 WP_16 WP_17 WP_18 WP_19 WP_20 WP_21
+  WP_22 WP_23 WP_24 WP_25 WP_26 WP_27 WP_28 WP_29 WP_30
** RA1SHBIT_COL: 3072 flat devices **
XI0_0 BL_0 BL BL_2 BL_4 BL_6 BL_8 BL_10 BL_12 BL_14 BL_16 BL_18 BL_20 BL_22
+  BL_24 BL_26 BL_28 BL_30 BL_1 BL_3 BL_5 BL_7 BL_9 BL_11 BL_13 BL_15 BL_17
+  BL_19 BL_21 BL_23 BL_25 BL_27 BL_29 WL_30 WP_30 RA1SHBIT_MUX_0
XI0_1 BL BL_0 BL_1 BL_3 BL_5 BL_7 BL_9 BL_11 BL_13 BL_15 BL_17 BL_19 BL_21
+  BL_23 BL_25 BL_27 BL_29 BL_2 BL_4 BL_6 BL_8 BL_10 BL_12 BL_14 BL_16 BL_18
+  BL_20 BL_22 BL_24 BL_26 BL_28 BL_30 WL_29 WP_29 RA1SHBIT_MUX_1
XI0_10 BL_0 BL BL_2 BL_4 BL_6 BL_8 BL_10 BL_12 BL_14 BL_16 BL_18 BL_20 BL_22
+  BL_24 BL_26 BL_28 BL_30 BL_1 BL_3 BL_5 BL_7 BL_9 BL_11 BL_13 BL_15 BL_17
+  BL_19 BL_21 BL_23 BL_25 BL_27 BL_29 WL_20 WP_20 RA1SHBIT_MUX_0
XI0_11 BL BL_0 BL_1 BL_3 BL_5 BL_7 BL_9 BL_11 BL_13 BL_15 BL_17 BL_19 BL_21
+  BL_23 BL_25 BL_27 BL_29 BL_2 BL_4 BL_6 BL_8 BL_10 BL_12 BL_14 BL_16 BL_18
+  BL_20 BL_22 BL_24 BL_26 BL_28 BL_30 WL_19 WP_19 RA1SHBIT_MUX_1
XI0_12 BL_0 BL BL_2 BL_4 BL_6 BL_8 BL_10 BL_12 BL_14 BL_16 BL_18 BL_20 BL_22
+  BL_24 BL_26 BL_28 BL_30 BL_1 BL_3 BL_5 BL_7 BL_9 BL_11 BL_13 BL_15 BL_17
+  BL_19 BL_21 BL_23 BL_25 BL_27 BL_29 WL_18 WP_18 RA1SHBIT_MUX_0
XI0_13 BL BL_0 BL_1 BL_3 BL_5 BL_7 BL_9 BL_11 BL_13 BL_15 BL_17 BL_19 BL_21
+  BL_23 BL_25 BL_27 BL_29 BL_2 BL_4 BL_6 BL_8 BL_10 BL_12 BL_14 BL_16 BL_18
+  BL_20 BL_22 BL_24 BL_26 BL_28 BL_30 WL_17 WP_17 RA1SHBIT_MUX_1
XI0_14 BL_0 BL BL_2 BL_4 BL_6 BL_8 BL_10 BL_12 BL_14 BL_16 BL_18 BL_20 BL_22
+  BL_24 BL_26 BL_28 BL_30 BL_1 BL_3 BL_5 BL_7 BL_9 BL_11 BL_13 BL_15 BL_17
+  BL_19 BL_21 BL_23 BL_25 BL_27 BL_29 WL_16 WP_16 RA1SHBIT_MUX_0
XI0_15 BL BL_0 BL_1 BL_3 BL_5 BL_7 BL_9 BL_11 BL_13 BL_15 BL_17 BL_19 BL_21
+  BL_23 BL_25 BL_27 BL_29 BL_2 BL_4 BL_6 BL_8 BL_10 BL_12 BL_14 BL_16 BL_18
+  BL_20 BL_22 BL_24 BL_26 BL_28 BL_30 WL_15 WP_15 RA1SHBIT_MUX_1
XI0_16 BL_0 BL BL_2 BL_4 BL_6 BL_8 BL_10 BL_12 BL_14 BL_16 BL_18 BL_20 BL_22
+  BL_24 BL_26 BL_28 BL_30 BL_1 BL_3 BL_5 BL_7 BL_9 BL_11 BL_13 BL_15 BL_17
+  BL_19 BL_21 BL_23 BL_25 BL_27 BL_29 WL_14 WP_14 RA1SHBIT_MUX_0
XI0_17 BL BL_0 BL_1 BL_3 BL_5 BL_7 BL_9 BL_11 BL_13 BL_15 BL_17 BL_19 BL_21
+  BL_23 BL_25 BL_27 BL_29 BL_2 BL_4 BL_6 BL_8 BL_10 BL_12 BL_14 BL_16 BL_18
+  BL_20 BL_22 BL_24 BL_26 BL_28 BL_30 WL_13 WP_13 RA1SHBIT_MUX_1
XI0_18 BL_0 BL BL_2 BL_4 BL_6 BL_8 BL_10 BL_12 BL_14 BL_16 BL_18 BL_20 BL_22
+  BL_24 BL_26 BL_28 BL_30 BL_1 BL_3 BL_5 BL_7 BL_9 BL_11 BL_13 BL_15 BL_17
+  BL_19 BL_21 BL_23 BL_25 BL_27 BL_29 WL_12 WP_12 RA1SHBIT_MUX_0
XI0_19 BL BL_0 BL_1 BL_3 BL_5 BL_7 BL_9 BL_11 BL_13 BL_15 BL_17 BL_19 BL_21
+  BL_23 BL_25 BL_27 BL_29 BL_2 BL_4 BL_6 BL_8 BL_10 BL_12 BL_14 BL_16 BL_18
+  BL_20 BL_22 BL_24 BL_26 BL_28 BL_30 WL_11 WP_11 RA1SHBIT_MUX_1
XI0_2 BL_0 BL BL_2 BL_4 BL_6 BL_8 BL_10 BL_12 BL_14 BL_16 BL_18 BL_20 BL_22
+  BL_24 BL_26 BL_28 BL_30 BL_1 BL_3 BL_5 BL_7 BL_9 BL_11 BL_13 BL_15 BL_17
+  BL_19 BL_21 BL_23 BL_25 BL_27 BL_29 WL_28 WP_28 RA1SHBIT_MUX_0
XI0_20 BL_0 BL BL_2 BL_4 BL_6 BL_8 BL_10 BL_12 BL_14 BL_16 BL_18 BL_20 BL_22
+  BL_24 BL_26 BL_28 BL_30 BL_1 BL_3 BL_5 BL_7 BL_9 BL_11 BL_13 BL_15 BL_17
+  BL_19 BL_21 BL_23 BL_25 BL_27 BL_29 WL_10 WP_10 RA1SHBIT_MUX_0
XI0_21 BL BL_0 BL_1 BL_3 BL_5 BL_7 BL_9 BL_11 BL_13 BL_15 BL_17 BL_19 BL_21
+  BL_23 BL_25 BL_27 BL_29 BL_2 BL_4 BL_6 BL_8 BL_10 BL_12 BL_14 BL_16 BL_18
+  BL_20 BL_22 BL_24 BL_26 BL_28 BL_30 WL_9 WP_9 RA1SHBIT_MUX_1
XI0_22 BL_0 BL BL_2 BL_4 BL_6 BL_8 BL_10 BL_12 BL_14 BL_16 BL_18 BL_20 BL_22
+  BL_24 BL_26 BL_28 BL_30 BL_1 BL_3 BL_5 BL_7 BL_9 BL_11 BL_13 BL_15 BL_17
+  BL_19 BL_21 BL_23 BL_25 BL_27 BL_29 WL_8 WP_8 RA1SHBIT_MUX_0
XI0_23 BL BL_0 BL_1 BL_3 BL_5 BL_7 BL_9 BL_11 BL_13 BL_15 BL_17 BL_19 BL_21
+  BL_23 BL_25 BL_27 BL_29 BL_2 BL_4 BL_6 BL_8 BL_10 BL_12 BL_14 BL_16 BL_18
+  BL_20 BL_22 BL_24 BL_26 BL_28 BL_30 WL_7 WP_7 RA1SHBIT_MUX_1
XI0_24 BL_0 BL BL_2 BL_4 BL_6 BL_8 BL_10 BL_12 BL_14 BL_16 BL_18 BL_20 BL_22
+  BL_24 BL_26 BL_28 BL_30 BL_1 BL_3 BL_5 BL_7 BL_9 BL_11 BL_13 BL_15 BL_17
+  BL_19 BL_21 BL_23 BL_25 BL_27 BL_29 WL_6 WP_6 RA1SHBIT_MUX_0
XI0_25 BL BL_0 BL_1 BL_3 BL_5 BL_7 BL_9 BL_11 BL_13 BL_15 BL_17 BL_19 BL_21
+  BL_23 BL_25 BL_27 BL_29 BL_2 BL_4 BL_6 BL_8 BL_10 BL_12 BL_14 BL_16 BL_18
+  BL_20 BL_22 BL_24 BL_26 BL_28 BL_30 WL_5 WP_5 RA1SHBIT_MUX_1
XI0_26 BL_0 BL BL_2 BL_4 BL_6 BL_8 BL_10 BL_12 BL_14 BL_16 BL_18 BL_20 BL_22
+  BL_24 BL_26 BL_28 BL_30 BL_1 BL_3 BL_5 BL_7 BL_9 BL_11 BL_13 BL_15 BL_17
+  BL_19 BL_21 BL_23 BL_25 BL_27 BL_29 WL_4 WP_4 RA1SHBIT_MUX_0
XI0_27 BL BL_0 BL_1 BL_3 BL_5 BL_7 BL_9 BL_11 BL_13 BL_15 BL_17 BL_19 BL_21
+  BL_23 BL_25 BL_27 BL_29 BL_2 BL_4 BL_6 BL_8 BL_10 BL_12 BL_14 BL_16 BL_18
+  BL_20 BL_22 BL_24 BL_26 BL_28 BL_30 WL_3 WP_3 RA1SHBIT_MUX_1
XI0_28 BL_0 BL BL_2 BL_4 BL_6 BL_8 BL_10 BL_12 BL_14 BL_16 BL_18 BL_20 BL_22
+  BL_24 BL_26 BL_28 BL_30 BL_1 BL_3 BL_5 BL_7 BL_9 BL_11 BL_13 BL_15 BL_17
+  BL_19 BL_21 BL_23 BL_25 BL_27 BL_29 WL_2 WP_2 RA1SHBIT_MUX_0
XI0_29 BL BL_0 BL_1 BL_3 BL_5 BL_7 BL_9 BL_11 BL_13 BL_15 BL_17 BL_19 BL_21
+  BL_23 BL_25 BL_27 BL_29 BL_2 BL_4 BL_6 BL_8 BL_10 BL_12 BL_14 BL_16 BL_18
+  BL_20 BL_22 BL_24 BL_26 BL_28 BL_30 WL_1 WP_1 RA1SHBIT_MUX_1
XI0_3 BL BL_0 BL_1 BL_3 BL_5 BL_7 BL_9 BL_11 BL_13 BL_15 BL_17 BL_19 BL_21
+  BL_23 BL_25 BL_27 BL_29 BL_2 BL_4 BL_6 BL_8 BL_10 BL_12 BL_14 BL_16 BL_18
+  BL_20 BL_22 BL_24 BL_26 BL_28 BL_30 WL_27 WP_27 RA1SHBIT_MUX_1
XI0_30 BL_0 BL BL_2 BL_4 BL_6 BL_8 BL_10 BL_12 BL_14 BL_16 BL_18 BL_20 BL_22
+  BL_24 BL_26 BL_28 BL_30 BL_1 BL_3 BL_5 BL_7 BL_9 BL_11 BL_13 BL_15 BL_17
+  BL_19 BL_21 BL_23 BL_25 BL_27 BL_29 WL_0 WP_0 RA1SHBIT_MUX_0
XI0_31 BL BL_0 BL_1 BL_3 BL_5 BL_7 BL_9 BL_11 BL_13 BL_15 BL_17 BL_19 BL_21
+  BL_23 BL_25 BL_27 BL_29 BL_2 BL_4 BL_6 BL_8 BL_10 BL_12 BL_14 BL_16 BL_18
+  BL_20 BL_22 BL_24 BL_26 BL_28 BL_30 WL WP RA1SHBIT_MUX_1
XI0_4 BL_0 BL BL_2 BL_4 BL_6 BL_8 BL_10 BL_12 BL_14 BL_16 BL_18 BL_20 BL_22
+  BL_24 BL_26 BL_28 BL_30 BL_1 BL_3 BL_5 BL_7 BL_9 BL_11 BL_13 BL_15 BL_17
+  BL_19 BL_21 BL_23 BL_25 BL_27 BL_29 WL_26 WP_26 RA1SHBIT_MUX_0
XI0_5 BL BL_0 BL_1 BL_3 BL_5 BL_7 BL_9 BL_11 BL_13 BL_15 BL_17 BL_19 BL_21
+  BL_23 BL_25 BL_27 BL_29 BL_2 BL_4 BL_6 BL_8 BL_10 BL_12 BL_14 BL_16 BL_18
+  BL_20 BL_22 BL_24 BL_26 BL_28 BL_30 WL_25 WP_25 RA1SHBIT_MUX_1
XI0_6 BL_0 BL BL_2 BL_4 BL_6 BL_8 BL_10 BL_12 BL_14 BL_16 BL_18 BL_20 BL_22
+  BL_24 BL_26 BL_28 BL_30 BL_1 BL_3 BL_5 BL_7 BL_9 BL_11 BL_13 BL_15 BL_17
+  BL_19 BL_21 BL_23 BL_25 BL_27 BL_29 WL_24 WP_24 RA1SHBIT_MUX_0
XI0_7 BL BL_0 BL_1 BL_3 BL_5 BL_7 BL_9 BL_11 BL_13 BL_15 BL_17 BL_19 BL_21
+  BL_23 BL_25 BL_27 BL_29 BL_2 BL_4 BL_6 BL_8 BL_10 BL_12 BL_14 BL_16 BL_18
+  BL_20 BL_22 BL_24 BL_26 BL_28 BL_30 WL_23 WP_23 RA1SHBIT_MUX_1
XI0_8 BL_0 BL BL_2 BL_4 BL_6 BL_8 BL_10 BL_12 BL_14 BL_16 BL_18 BL_20 BL_22
+  BL_24 BL_26 BL_28 BL_30 BL_1 BL_3 BL_5 BL_7 BL_9 BL_11 BL_13 BL_15 BL_17
+  BL_19 BL_21 BL_23 BL_25 BL_27 BL_29 WL_22 WP_22 RA1SHBIT_MUX_0
XI0_9 BL BL_0 BL_1 BL_3 BL_5 BL_7 BL_9 BL_11 BL_13 BL_15 BL_17 BL_19 BL_21
+  BL_23 BL_25 BL_27 BL_29 BL_2 BL_4 BL_6 BL_8 BL_10 BL_12 BL_14 BL_16 BL_18
+  BL_20 BL_22 BL_24 BL_26 BL_28 BL_30 WL_21 WP_21 RA1SHBIT_MUX_1
.ENDS RA1SHBIT_COL
****
.SUBCKT RA1SHMXCOL_ODD_LEFT A0 A0_ BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6
+  BL_7 BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 D GTP
+  GTP_0 GTP_1 OE_ Q QI STUBDR STUBDR_ STUBDR_0 STUBDR__0 STUBDW STUBDW_
+  STUBDW_0 STUBDW__0 WE WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21
+  WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WP WP_0 WP_1 WP_2
+  WP_3 WP_4 WP_5 WP_6 WP_7 WP_8 WP_9 WP_10 WP_11 WP_12 WP_13 WP_14 WP_15
+  WP_16 WP_17 WP_18 WP_19 WP_20 WP_21 WP_22 WP_23 WP_24 WP_25 WP_26 WP_27
+  WP_28 WP_29 WP_30 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3
** RA1SHMXCOL_ODD_LEFT: 3520 flat devices **
XI0_0 OE_ GTP_1 WE RA1SHFLIO
XI0_1 GTP_0 RA1SHFLSA
XI0_2 A0 A0_ BL BL_ BL__2 BL_3 BL__6 BL_7 BL__10 BL_11 BL__14 BL_2 BL__3 BL_6
+  BL__7 BL_10 BL__11 BL_14 BL__0 BL_0 BL_1 BL__4 BL_5 BL__8 BL_9 BL__12 BL_13
+  BL__1 BL_4 BL__5 BL_8 BL__9 BL_12 BL__13 VSS STUBDR_ STUBDR VSS VSS VSS VSS
+  VSS VSS STUBDW_ VSS VSS VSS VSS VSS GTP STUBDR_0 STUBDR__0 STUBDW STUBDW_0
+  STUBDW__0 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 RA1SHMUX_CD_ODD
XI0_3 BL BL_ BL_0 BL__0 BL_1 BL__1 BL_2 BL__2 BL_3 BL__3 BL_4 BL__4 BL_5 BL__5
+  BL_6 BL__6 BL_7 BL__7 BL_8 BL__8 BL_9 BL__9 BL_10 BL__10 BL_11 BL__11 BL_12
+  BL__12 BL_13 BL__13 BL_14 BL__14 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WP WP_0 WP_1
+  WP_2 WP_3 WP_4 WP_5 WP_6 WP_7 WP_8 WP_9 WP_10 WP_11 WP_12 WP_13 WP_14 WP_15
+  WP_16 WP_17 WP_18 WP_19 WP_20 WP_21 WP_22 WP_23 WP_24 WP_25 WP_26 WP_27
+  WP_28 WP_29 WP_30 RA1SHBIT_COL
XI1_0 D DI_ DPN DPU STUBDW STUBDW_ GTP_1 IO IO_1 OE_ Q QI SP WE RA1SHIOX
XI1_1 DPN DPU STUBDR STUBDR_ STUBDW STUBDW_ GTP_0 SP RA1SHSA8
.ENDS RA1SHMXCOL_ODD_LEFT
****
.SUBCKT RA1SHCOLS_1_LEFT A0 A0_ BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5
+  BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 D DR DR_ DW DW_
+  GTP GTP_0 GTP_1 OE_ Q QI STUBDR STUBDR_ STUBDW STUBDW_ WE WL WL_0 WL_1 WL_2
+  WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15
+  WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27
+  WL_28 WL_29 WL_30 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3
** RA1SHCOLS_1_LEFT: 3520 flat devices **
XI0_0 A0 A0_ BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10
+  BL_11 BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 D GTP GTP_0 GTP_1 OE_ Q QI
+  DR DR_ STUBDR STUBDR_ DW DW_ STUBDW STUBDW_ WE WL WL_0 WL_1 WL_2 WL_3 WL_4
+  WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17
+  WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29
+  WL_30 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0
+  YP1_1 YP1_2 YP1_3 RA1SHMXCOL_ODD_LEFT
.ENDS RA1SHCOLS_1_LEFT
****
.SUBCKT RA1SHCOLS_NS_1_LEFT A0 A0_ BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6
+  BL_7 BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 D GTP
+  GTP_0 GTP_1 OE_ Q QI STUBDR STUBDR_ STUBDR_0 STUBDR__0 STUBDW STUBDW_
+  STUBDW_0 STUBDW__0 WE WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21
+  WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WP WP_0 WP_1 WP_2
+  WP_3 WP_4 WP_5 WP_6 WP_7 WP_8 WP_9 WP_10 WP_11 WP_12 WP_13 WP_14 WP_15
+  WP_16 WP_17 WP_18 WP_19 WP_20 WP_21 WP_22 WP_23 WP_24 WP_25 WP_26 WP_27
+  WP_28 WP_29 WP_30 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3
** RA1SHCOLS_NS_1_LEFT: 3520 flat devices **
XI0_0 A0 A0_ BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10
+  BL_11 BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 D GTP GTP_0 GTP_1 OE_ Q QI
+  STUBDR STUBDR_ STUBDR_0 STUBDR__0 STUBDW STUBDW_ STUBDW_0 STUBDW__0 WE WL
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WP WP_0 WP_1 WP_2 WP_3 WP_4 WP_5 WP_6 WP_7
+  WP_8 WP_9 WP_10 WP_11 WP_12 WP_13 WP_14 WP_15 WP_16 WP_17 WP_18 WP_19 WP_20
+  WP_21 WP_22 WP_23 WP_24 WP_25 WP_26 WP_27 WP_28 WP_29 WP_30 YP0_0 YP0_1
+  YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 RA1SHMXCOL_ODD_LEFT
.ENDS RA1SHCOLS_NS_1_LEFT
****
.SUBCKT RA1SHWING_6_LEFT A0 A0_ BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20
+  BL_21 BL_22 BL_23 BL_24 BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32
+  BL_33 BL_34 BL_35 BL_36 BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44
+  BL_45 BL_46 BL_47 BL_48 BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56
+  BL_57 BL_58 BL_59 BL_60 BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68
+  BL_69 BL_70 BL_71 BL_72 BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80
+  BL_81 BL_82 BL_83 BL_84 BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92
+  BL_93 BL_94 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19
+  BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29
+  BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39
+  BL__40 BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49
+  BL__50 BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59
+  BL__60 BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69
+  BL__70 BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79
+  BL__80 BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89
+  BL__90 BL__91 BL__92 BL__93 BL__94 D D_0 D_1 D_2 D_3 D_4 GTP GTP_0 GTP_1
+  OE_ Q QI QI_0 QI_1 QI_2 QI_3 QI_4 Q_0 Q_1 Q_2 Q_3 Q_4 STUBDR STUBDR_
+  STUBDR_0 STUBDR__0 STUBDW STUBDW_ STUBDW_0 STUBDW__0 WE WL WL_0 WL_1 WL_2
+  WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15
+  WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27
+  WL_28 WL_29 WL_30 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3
** RA1SHWING_6_LEFT: 21120 flat devices **
XI0_0 A0 A0_ BL_79 BL__79 BL_80 BL_81 BL_82 BL_83 BL_84 BL_85 BL_86 BL_87
+  BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL__80 BL__81 BL__82 BL__83
+  BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90 BL__91 BL__92 BL__93
+  BL__94 D_4 DR DR_ DW DW_ GTP GTP_0 GTP_1 OE_ Q_4 QI_4 STUBDR_0 STUBDR__0
+  STUBDW_0 STUBDW__0 WE WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21
+  WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 YP0_0 YP0_1 YP0_2
+  YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 RA1SHCOLS_1_LEFT
XI1_0 A0 A0_ BL_63 BL__63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71
+  BL_72 BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL__64 BL__65 BL__66 BL__67
+  BL__68 BL__69 BL__70 BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77
+  BL__78 D_3 DR_6 DR__4 DW_8 DW__10 GTP GTP_0 GTP_1 OE_ Q_3 QI_3 DR DR_ DW
+  DW_ WE WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0
+  YP1_1 YP1_2 YP1_3 RA1SHCOLS_1_LEFT
XI2_0 A0 A0_ BL_47 BL__47 BL_48 BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55
+  BL_56 BL_57 BL_58 BL_59 BL_60 BL_61 BL_62 BL__48 BL__49 BL__50 BL__51
+  BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60 BL__61
+  BL__62 D_2 DR_14 DR__12 DW_16 DW__18 GTP GTP_0 GTP_1 OE_ Q_2 QI_2 DR_6
+  DR__4 DW_8 DW__10 WE WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21
+  WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 YP0_0 YP0_1 YP0_2
+  YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 RA1SHCOLS_1_LEFT
XI3_0 A0 A0_ BL_31 BL__31 BL_32 BL_33 BL_34 BL_35 BL_36 BL_37 BL_38 BL_39
+  BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL__32 BL__33 BL__34 BL__35
+  BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 BL__44 BL__45
+  BL__46 D_1 DR_22 DR__20 DW_24 DW__26 GTP GTP_0 GTP_1 OE_ Q_1 QI_1 DR_14
+  DR__12 DW_16 DW__18 WE WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21
+  WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 YP0_0 YP0_1 YP0_2
+  YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 RA1SHCOLS_1_LEFT
XI4_0 A0 A0_ BL_15 BL__15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23
+  BL_24 BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL__16 BL__17 BL__18 BL__19
+  BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29
+  BL__30 D_0 DR_30 DR__28 DW_32 DW__34 GTP GTP_0 GTP_1 OE_ Q_0 QI_0 DR_22
+  DR__20 DW_24 DW__26 WE WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21
+  WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 YP0_0 YP0_1 YP0_2
+  YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 RA1SHCOLS_1_LEFT
XI5_0 A0 A0_ BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10
+  BL_11 BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 D GTP GTP_0 GTP_1 OE_ Q QI
+  STUBDR STUBDR_ DR_30 DR__28 STUBDW STUBDW_ DW_32 DW__34 WE WL WL_0 WL_1
+  WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15
+  WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27
+  WL_28 WL_29 WL_30 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21
+  WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 YP0_0 YP0_1 YP0_2
+  YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 RA1SHCOLS_NS_1_LEFT
.ENDS RA1SHWING_6_LEFT
****
.SUBCKT RA1SHHXP24 A0 A1 ACONN0 ACONN1 AGTPB AGTPT AMX0 AMX1 AY0 AY0_ OEI_ WEI
+  XP_0 XP_1 XP_2 XP_3 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3
** RA1SHHXP24: 100 flat devices **
d15 VSS ACONN1 DN 0.36P 2.4U
d16 VSS A1 DN 0.36P 2.4U
d7 VSS ACONN0 DN 0.36P 2.4U
d8 VSS A0 DN 0.36P 2.4U
m1 N28 N35 VDD VDD P L=0.18U W=6.72U
m10 N32 N44 VSS VSS N L=0.18U W=3.22U
m100 XP_3 AP_I6-APN0 VSS VSS N L=0.18U W=9U
m11 N31 ACONN1 VDD VDD P L=0.18U W=6.72U
m12 N31 ACONN1 VSS VSS N L=0.18U W=3.22U
m13 N44 ACONN1 VDD VDD P L=0.18U W=5.36U
m14 N44 ACONN1 VSS VSS N L=0.18U W=2.56U
m17 AP_I5-APN1 N61 AP_I5-AIND1 VSS N L=0.18U W=4.84U
m18 AP_I5-APN1 AGTPT AP_I5-AIND1 VDD P L=0.18U W=8.54U
m19 N61 AGTPT VDD VDD P L=0.18U W=1.16U
m2 N28 N35 VSS VSS N L=0.18U W=3.22U
m20 N61 AGTPT VSS VSS N L=0.18U W=0.72U
m21 AP_I5-AIN21 N28 VDD VDD P L=0.18U W=4.82U
m22 AP_I5-AIN21 N28 VSS VSS N L=0.18U W=2.26U
m23 N55 N32 VDD VDD P L=0.18U W=4.82U
m24 N55 N32 VSS VSS N L=0.18U W=2.26U
m25 N56 VSS VDD VDD P L=0.18U W=4.82U
m26 N56 VSS VSS VSS N L=0.18U W=2.26U
m27 N90 N56 VSS VSS N L=0.18U W=4.86U
m28 N89 N55 N90 VSS N L=0.18U W=4.86U
m29 AP_I5-AIND1 AP_I5-AIN21 N89 VSS N L=0.18U W=4.86U
m3 N27 ACONN0 VDD VDD P L=0.18U W=6.72U
m30 AP_I5-AIND1 N56 VDD VDD P L=0.18U W=8.52U
m31 N88 N56 VSS VSS N L=0.18U W=4.86U
m32 AP_I5-AIND1 N55 VDD VDD P L=0.18U W=8.52U
m33 N87 N55 N88 VSS N L=0.18U W=4.86U
m34 AP_I5-AIND1 AP_I5-AIN21 VDD VDD P L=0.18U W=8.52U
m35 AP_I5-AIND1 AP_I5-AIN21 N87 VSS N L=0.18U W=4.86U
m36 AP_I5-APN0 N72 AP_I5-AIND0 VSS N L=0.18U W=4.84U
m37 AP_I5-APN0 AGTPB AP_I5-AIND0 VDD P L=0.18U W=8.54U
m38 N72 AGTPB VDD VDD P L=0.18U W=1.16U
m39 N72 AGTPB VSS VSS N L=0.18U W=0.72U
m4 N27 ACONN0 VSS VSS N L=0.18U W=3.22U
m40 AP_I5-AIN20 N27 VDD VDD P L=0.18U W=4.82U
m41 AP_I5-AIN20 N27 VSS VSS N L=0.18U W=2.26U
m42 N94 N56 VSS VSS N L=0.18U W=4.86U
m43 N93 N55 N94 VSS N L=0.18U W=4.86U
m44 AP_I5-AIND0 AP_I5-AIN20 N93 VSS N L=0.18U W=4.86U
m45 AP_I5-AIND0 N56 VDD VDD P L=0.18U W=8.52U
m46 N92 N56 VSS VSS N L=0.18U W=4.86U
m47 AP_I5-AIND0 N55 VDD VDD P L=0.18U W=8.52U
m48 N91 N55 N92 VSS N L=0.18U W=4.86U
m49 AP_I5-AIND0 AP_I5-AIN20 VDD VDD P L=0.18U W=8.52U
m5 N35 ACONN0 VDD VDD P L=0.18U W=5.36U
m50 AP_I5-AIND0 AP_I5-AIN20 N91 VSS N L=0.18U W=4.86U
m51 AP_I5-APN1 XP_0 VDD VDD P L=0.28U W=0.24U
m52 AP_I5-APN1 XP_0 VSS VSS N L=0.54U W=0.24U
m53 XP_0 AP_I5-APN1 VDD VDD P L=0.18U W=25U
m54 XP_0 AP_I5-APN1 VSS VSS N L=0.18U W=9U
m55 AP_I5-APN0 XP_1 VDD VDD P L=0.28U W=0.24U
m56 AP_I5-APN0 XP_1 VSS VSS N L=0.54U W=0.24U
m57 XP_1 AP_I5-APN0 VDD VDD P L=0.18U W=25U
m58 XP_1 AP_I5-APN0 VSS VSS N L=0.18U W=9U
m59 AP_I6-APN1 N103 AP_I6-AIND1 VSS N L=0.18U W=4.84U
m6 N35 ACONN0 VSS VSS N L=0.18U W=2.56U
m60 AP_I6-APN1 AGTPT AP_I6-AIND1 VDD P L=0.18U W=8.54U
m61 N103 AGTPT VDD VDD P L=0.18U W=1.16U
m62 N103 AGTPT VSS VSS N L=0.18U W=0.72U
m63 AP_I6-AIN21 N28 VDD VDD P L=0.18U W=4.82U
m64 AP_I6-AIN21 N28 VSS VSS N L=0.18U W=2.26U
m65 N97 N31 VDD VDD P L=0.18U W=4.82U
m66 N97 N31 VSS VSS N L=0.18U W=2.26U
m67 N98 VSS VDD VDD P L=0.18U W=4.82U
m68 N98 VSS VSS VSS N L=0.18U W=2.26U
m69 N132 N98 VSS VSS N L=0.18U W=4.86U
m70 N131 N97 N132 VSS N L=0.18U W=4.86U
m71 AP_I6-AIND1 AP_I6-AIN21 N131 VSS N L=0.18U W=4.86U
m72 AP_I6-AIND1 N98 VDD VDD P L=0.18U W=8.52U
m73 N130 N98 VSS VSS N L=0.18U W=4.86U
m74 AP_I6-AIND1 N97 VDD VDD P L=0.18U W=8.52U
m75 N129 N97 N130 VSS N L=0.18U W=4.86U
m76 AP_I6-AIND1 AP_I6-AIN21 VDD VDD P L=0.18U W=8.52U
m77 AP_I6-AIND1 AP_I6-AIN21 N129 VSS N L=0.18U W=4.86U
m78 AP_I6-APN0 N114 AP_I6-AIND0 VSS N L=0.18U W=4.84U
m79 AP_I6-APN0 AGTPB AP_I6-AIND0 VDD P L=0.18U W=8.54U
m80 N114 AGTPB VDD VDD P L=0.18U W=1.16U
m81 N114 AGTPB VSS VSS N L=0.18U W=0.72U
m82 AP_I6-AIN20 N27 VDD VDD P L=0.18U W=4.82U
m83 AP_I6-AIN20 N27 VSS VSS N L=0.18U W=2.26U
m84 N136 N98 VSS VSS N L=0.18U W=4.86U
m85 N135 N97 N136 VSS N L=0.18U W=4.86U
m86 AP_I6-AIND0 AP_I6-AIN20 N135 VSS N L=0.18U W=4.86U
m87 AP_I6-AIND0 N98 VDD VDD P L=0.18U W=8.52U
m88 N134 N98 VSS VSS N L=0.18U W=4.86U
m89 AP_I6-AIND0 N97 VDD VDD P L=0.18U W=8.52U
m9 N32 N44 VDD VDD P L=0.18U W=6.72U
m90 N133 N97 N134 VSS N L=0.18U W=4.86U
m91 AP_I6-AIND0 AP_I6-AIN20 VDD VDD P L=0.18U W=8.52U
m92 AP_I6-AIND0 AP_I6-AIN20 N133 VSS N L=0.18U W=4.86U
m93 AP_I6-APN1 XP_2 VDD VDD P L=0.28U W=0.24U
m94 AP_I6-APN1 XP_2 VSS VSS N L=0.54U W=0.24U
m95 XP_2 AP_I6-APN1 VDD VDD P L=0.18U W=25U
m96 XP_2 AP_I6-APN1 VSS VSS N L=0.18U W=9U
m97 AP_I6-APN0 XP_3 VDD VDD P L=0.28U W=0.24U
m98 AP_I6-APN0 XP_3 VSS VSS N L=0.54U W=0.24U
m99 XP_3 AP_I6-APN0 VDD VDD P L=0.18U W=25U
.ENDS RA1SHHXP24
****
.SUBCKT RA1SHHXP24X A0 A1 AGTPB AGTPT AY0 AY0_ OEI_ WEI XP_0 XP_1 XP_2 XP_3
+  YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3
** RA1SHHXP24X: 100 flat devices **
XI0_0 A0 A1 A0 A1 AGTPB AGTPT VSS VSS AY0 AY0_ OEI_ WEI XP_0 XP_1 XP_2 XP_3
+  YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 RA1SHHXP24
.ENDS RA1SHHXP24X
****
.SUBCKT RA1SHHXP38 A0 A1 A2 ACONN0 ACONN1 ACONN2 AGTPB AGTPT AMX0 AMX1 AMX2
+  AY0 AY0_ OEI_ WEI XP_0 XP_1 XP_2 XP_3 XP_4 XP_5 XP_6 XP_7 YP0_0 YP0_1 YP0_2
+  YP0_3 YP1_0 YP1_1 YP1_2 YP1_3
** RA1SHHXP38: 192 flat devices **
d175 VSS ACONN2 DN 0.36P 2.4U
d176 VSS A2 DN 0.36P 2.4U
d183 VSS ACONN1 DN 0.36P 2.4U
d184 VSS A1 DN 0.36P 2.4U
d191 VSS ACONN0 DN 0.36P 2.4U
d192 VSS A0 DN 0.36P 2.4U
m1 AP67-APN1 N53 AP67-AIND1 VSS N L=0.18U W=4.84U
m10 N48 AI2_ VSS VSS N L=0.18U W=2.26U
m100 AP23-AIND1 N131 VDD VDD P L=0.18U W=8.52U
m101 N163 N131 N164 VSS N L=0.18U W=4.86U
m102 AP23-AIND1 AP23-AIN21 VDD VDD P L=0.18U W=8.52U
m103 AP23-AIND1 AP23-AIN21 N163 VSS N L=0.18U W=4.86U
m104 AP23-APN0 N148 AP23-AIND0 VSS N L=0.18U W=4.84U
m105 AP23-APN0 AGTPB AP23-AIND0 VDD P L=0.18U W=8.54U
m106 N148 AGTPB VDD VDD P L=0.18U W=1.16U
m107 N148 AGTPB VSS VSS N L=0.18U W=0.72U
m108 AP23-AIN20 AI0 VDD VDD P L=0.18U W=4.82U
m109 AP23-AIN20 AI0 VSS VSS N L=0.18U W=2.26U
m11 N82 N48 VSS VSS N L=0.18U W=4.86U
m110 N170 N132 VSS VSS N L=0.18U W=4.86U
m111 N169 N131 N170 VSS N L=0.18U W=4.86U
m112 AP23-AIND0 AP23-AIN20 N169 VSS N L=0.18U W=4.86U
m113 AP23-AIND0 N132 VDD VDD P L=0.18U W=8.52U
m114 N168 N132 VSS VSS N L=0.18U W=4.86U
m115 AP23-AIND0 N131 VDD VDD P L=0.18U W=8.52U
m116 N167 N131 N168 VSS N L=0.18U W=4.86U
m117 AP23-AIND0 AP23-AIN20 VDD VDD P L=0.18U W=8.52U
m118 AP23-AIND0 AP23-AIN20 N167 VSS N L=0.18U W=4.86U
m119 AP23-APN1 XP_3 VDD VDD P L=0.28U W=0.24U
m12 N81 N47 N82 VSS N L=0.18U W=4.86U
m120 AP23-APN1 XP_3 VSS VSS N L=0.54U W=0.24U
m121 XP_3 AP23-APN1 VDD VDD P L=0.18U W=25U
m122 XP_3 AP23-APN1 VSS VSS N L=0.18U W=9U
m123 AP23-APN0 XP_2 VDD VDD P L=0.28U W=0.24U
m124 AP23-APN0 XP_2 VSS VSS N L=0.54U W=0.24U
m125 XP_2 AP23-APN0 VDD VDD P L=0.18U W=25U
m126 XP_2 AP23-APN0 VSS VSS N L=0.18U W=9U
m127 AP01-APN1 N179 AP01-AIND1 VSS N L=0.18U W=4.84U
m128 AP01-APN1 AGTPT AP01-AIND1 VDD P L=0.18U W=8.54U
m129 N179 AGTPT VDD VDD P L=0.18U W=1.16U
m13 AP67-AIND1 AP67-AIN21 N81 VSS N L=0.18U W=4.86U
m130 N179 AGTPT VSS VSS N L=0.18U W=0.72U
m131 AP01-AIN21 AI0_ VDD VDD P L=0.18U W=4.82U
m132 AP01-AIN21 AI0_ VSS VSS N L=0.18U W=2.26U
m133 N173 AI1 VDD VDD P L=0.18U W=4.82U
m134 N173 AI1 VSS VSS N L=0.18U W=2.26U
m135 N174 AI2 VDD VDD P L=0.18U W=4.82U
m136 N174 AI2 VSS VSS N L=0.18U W=2.26U
m137 N208 N174 VSS VSS N L=0.18U W=4.86U
m138 N207 N173 N208 VSS N L=0.18U W=4.86U
m139 AP01-AIND1 AP01-AIN21 N207 VSS N L=0.18U W=4.86U
m14 AP67-AIND1 N48 VDD VDD P L=0.18U W=8.52U
m140 AP01-AIND1 N174 VDD VDD P L=0.18U W=8.52U
m141 N206 N174 VSS VSS N L=0.18U W=4.86U
m142 AP01-AIND1 N173 VDD VDD P L=0.18U W=8.52U
m143 N205 N173 N206 VSS N L=0.18U W=4.86U
m144 AP01-AIND1 AP01-AIN21 VDD VDD P L=0.18U W=8.52U
m145 AP01-AIND1 AP01-AIN21 N205 VSS N L=0.18U W=4.86U
m146 AP01-APN0 N190 AP01-AIND0 VSS N L=0.18U W=4.84U
m147 AP01-APN0 AGTPB AP01-AIND0 VDD P L=0.18U W=8.54U
m148 N190 AGTPB VDD VDD P L=0.18U W=1.16U
m149 N190 AGTPB VSS VSS N L=0.18U W=0.72U
m15 N80 N48 VSS VSS N L=0.18U W=4.86U
m150 AP01-AIN20 AI0 VDD VDD P L=0.18U W=4.82U
m151 AP01-AIN20 AI0 VSS VSS N L=0.18U W=2.26U
m152 N212 N174 VSS VSS N L=0.18U W=4.86U
m153 N211 N173 N212 VSS N L=0.18U W=4.86U
m154 AP01-AIND0 AP01-AIN20 N211 VSS N L=0.18U W=4.86U
m155 AP01-AIND0 N174 VDD VDD P L=0.18U W=8.52U
m156 N210 N174 VSS VSS N L=0.18U W=4.86U
m157 AP01-AIND0 N173 VDD VDD P L=0.18U W=8.52U
m158 N209 N173 N210 VSS N L=0.18U W=4.86U
m159 AP01-AIND0 AP01-AIN20 VDD VDD P L=0.18U W=8.52U
m16 AP67-AIND1 N47 VDD VDD P L=0.18U W=8.52U
m160 AP01-AIND0 AP01-AIN20 N209 VSS N L=0.18U W=4.86U
m161 AP01-APN1 XP_1 VDD VDD P L=0.28U W=0.24U
m162 AP01-APN1 XP_1 VSS VSS N L=0.54U W=0.24U
m163 XP_1 AP01-APN1 VDD VDD P L=0.18U W=25U
m164 XP_1 AP01-APN1 VSS VSS N L=0.18U W=9U
m165 AP01-APN0 XP_0 VDD VDD P L=0.28U W=0.24U
m166 AP01-APN0 XP_0 VSS VSS N L=0.54U W=0.24U
m167 XP_0 AP01-APN0 VDD VDD P L=0.18U W=25U
m168 XP_0 AP01-APN0 VSS VSS N L=0.18U W=9U
m169 AI2 N213 VDD VDD P L=0.18U W=6.72U
m17 N79 N47 N80 VSS N L=0.18U W=4.86U
m170 AI2 N213 VSS VSS N L=0.18U W=3.22U
m171 AI2_ ACONN2 VDD VDD P L=0.18U W=6.72U
m172 AI2_ ACONN2 VSS VSS N L=0.18U W=3.22U
m173 N213 ACONN2 VDD VDD P L=0.18U W=5.36U
m174 N213 ACONN2 VSS VSS N L=0.18U W=2.56U
m177 AI1 N222 VDD VDD P L=0.18U W=6.72U
m178 AI1 N222 VSS VSS N L=0.18U W=3.22U
m179 AI1_ ACONN1 VDD VDD P L=0.18U W=6.72U
m18 AP67-AIND1 AP67-AIN21 VDD VDD P L=0.18U W=8.52U
m180 AI1_ ACONN1 VSS VSS N L=0.18U W=3.22U
m181 N222 ACONN1 VDD VDD P L=0.18U W=5.36U
m182 N222 ACONN1 VSS VSS N L=0.18U W=2.56U
m185 AI0 N231 VDD VDD P L=0.18U W=6.72U
m186 AI0 N231 VSS VSS N L=0.18U W=3.22U
m187 AI0_ ACONN0 VDD VDD P L=0.18U W=6.72U
m188 AI0_ ACONN0 VSS VSS N L=0.18U W=3.22U
m189 N231 ACONN0 VDD VDD P L=0.18U W=5.36U
m19 AP67-AIND1 AP67-AIN21 N79 VSS N L=0.18U W=4.86U
m190 N231 ACONN0 VSS VSS N L=0.18U W=2.56U
m2 AP67-APN1 AGTPT AP67-AIND1 VDD P L=0.18U W=8.54U
m20 AP67-APN0 N64 AP67-AIND0 VSS N L=0.18U W=4.84U
m21 AP67-APN0 AGTPB AP67-AIND0 VDD P L=0.18U W=8.54U
m22 N64 AGTPB VDD VDD P L=0.18U W=1.16U
m23 N64 AGTPB VSS VSS N L=0.18U W=0.72U
m24 AP67-AIN20 AI0 VDD VDD P L=0.18U W=4.82U
m25 AP67-AIN20 AI0 VSS VSS N L=0.18U W=2.26U
m26 N86 N48 VSS VSS N L=0.18U W=4.86U
m27 N85 N47 N86 VSS N L=0.18U W=4.86U
m28 AP67-AIND0 AP67-AIN20 N85 VSS N L=0.18U W=4.86U
m29 AP67-AIND0 N48 VDD VDD P L=0.18U W=8.52U
m3 N53 AGTPT VDD VDD P L=0.18U W=1.16U
m30 N84 N48 VSS VSS N L=0.18U W=4.86U
m31 AP67-AIND0 N47 VDD VDD P L=0.18U W=8.52U
m32 N83 N47 N84 VSS N L=0.18U W=4.86U
m33 AP67-AIND0 AP67-AIN20 VDD VDD P L=0.18U W=8.52U
m34 AP67-AIND0 AP67-AIN20 N83 VSS N L=0.18U W=4.86U
m35 AP67-APN1 XP_7 VDD VDD P L=0.28U W=0.24U
m36 AP67-APN1 XP_7 VSS VSS N L=0.54U W=0.24U
m37 XP_7 AP67-APN1 VDD VDD P L=0.18U W=25U
m38 XP_7 AP67-APN1 VSS VSS N L=0.18U W=9U
m39 AP67-APN0 XP_6 VDD VDD P L=0.28U W=0.24U
m4 N53 AGTPT VSS VSS N L=0.18U W=0.72U
m40 AP67-APN0 XP_6 VSS VSS N L=0.54U W=0.24U
m41 XP_6 AP67-APN0 VDD VDD P L=0.18U W=25U
m42 XP_6 AP67-APN0 VSS VSS N L=0.18U W=9U
m43 AP45-APN1 N95 AP45-AIND1 VSS N L=0.18U W=4.84U
m44 AP45-APN1 AGTPT AP45-AIND1 VDD P L=0.18U W=8.54U
m45 N95 AGTPT VDD VDD P L=0.18U W=1.16U
m46 N95 AGTPT VSS VSS N L=0.18U W=0.72U
m47 AP45-AIN21 AI0_ VDD VDD P L=0.18U W=4.82U
m48 AP45-AIN21 AI0_ VSS VSS N L=0.18U W=2.26U
m49 N89 AI1 VDD VDD P L=0.18U W=4.82U
m5 AP67-AIN21 AI0_ VDD VDD P L=0.18U W=4.82U
m50 N89 AI1 VSS VSS N L=0.18U W=2.26U
m51 N90 AI2_ VDD VDD P L=0.18U W=4.82U
m52 N90 AI2_ VSS VSS N L=0.18U W=2.26U
m53 N124 N90 VSS VSS N L=0.18U W=4.86U
m54 N123 N89 N124 VSS N L=0.18U W=4.86U
m55 AP45-AIND1 AP45-AIN21 N123 VSS N L=0.18U W=4.86U
m56 AP45-AIND1 N90 VDD VDD P L=0.18U W=8.52U
m57 N122 N90 VSS VSS N L=0.18U W=4.86U
m58 AP45-AIND1 N89 VDD VDD P L=0.18U W=8.52U
m59 N121 N89 N122 VSS N L=0.18U W=4.86U
m6 AP67-AIN21 AI0_ VSS VSS N L=0.18U W=2.26U
m60 AP45-AIND1 AP45-AIN21 VDD VDD P L=0.18U W=8.52U
m61 AP45-AIND1 AP45-AIN21 N121 VSS N L=0.18U W=4.86U
m62 AP45-APN0 N106 AP45-AIND0 VSS N L=0.18U W=4.84U
m63 AP45-APN0 AGTPB AP45-AIND0 VDD P L=0.18U W=8.54U
m64 N106 AGTPB VDD VDD P L=0.18U W=1.16U
m65 N106 AGTPB VSS VSS N L=0.18U W=0.72U
m66 AP45-AIN20 AI0 VDD VDD P L=0.18U W=4.82U
m67 AP45-AIN20 AI0 VSS VSS N L=0.18U W=2.26U
m68 N128 N90 VSS VSS N L=0.18U W=4.86U
m69 N127 N89 N128 VSS N L=0.18U W=4.86U
m7 N47 AI1_ VDD VDD P L=0.18U W=4.82U
m70 AP45-AIND0 AP45-AIN20 N127 VSS N L=0.18U W=4.86U
m71 AP45-AIND0 N90 VDD VDD P L=0.18U W=8.52U
m72 N126 N90 VSS VSS N L=0.18U W=4.86U
m73 AP45-AIND0 N89 VDD VDD P L=0.18U W=8.52U
m74 N125 N89 N126 VSS N L=0.18U W=4.86U
m75 AP45-AIND0 AP45-AIN20 VDD VDD P L=0.18U W=8.52U
m76 AP45-AIND0 AP45-AIN20 N125 VSS N L=0.18U W=4.86U
m77 AP45-APN1 XP_5 VDD VDD P L=0.28U W=0.24U
m78 AP45-APN1 XP_5 VSS VSS N L=0.54U W=0.24U
m79 XP_5 AP45-APN1 VDD VDD P L=0.18U W=25U
m8 N47 AI1_ VSS VSS N L=0.18U W=2.26U
m80 XP_5 AP45-APN1 VSS VSS N L=0.18U W=9U
m81 AP45-APN0 XP_4 VDD VDD P L=0.28U W=0.24U
m82 AP45-APN0 XP_4 VSS VSS N L=0.54U W=0.24U
m83 XP_4 AP45-APN0 VDD VDD P L=0.18U W=25U
m84 XP_4 AP45-APN0 VSS VSS N L=0.18U W=9U
m85 AP23-APN1 N137 AP23-AIND1 VSS N L=0.18U W=4.84U
m86 AP23-APN1 AGTPT AP23-AIND1 VDD P L=0.18U W=8.54U
m87 N137 AGTPT VDD VDD P L=0.18U W=1.16U
m88 N137 AGTPT VSS VSS N L=0.18U W=0.72U
m89 AP23-AIN21 AI0_ VDD VDD P L=0.18U W=4.82U
m9 N48 AI2_ VDD VDD P L=0.18U W=4.82U
m90 AP23-AIN21 AI0_ VSS VSS N L=0.18U W=2.26U
m91 N131 AI1_ VDD VDD P L=0.18U W=4.82U
m92 N131 AI1_ VSS VSS N L=0.18U W=2.26U
m93 N132 AI2 VDD VDD P L=0.18U W=4.82U
m94 N132 AI2 VSS VSS N L=0.18U W=2.26U
m95 N166 N132 VSS VSS N L=0.18U W=4.86U
m96 N165 N131 N166 VSS N L=0.18U W=4.86U
m97 AP23-AIND1 AP23-AIN21 N165 VSS N L=0.18U W=4.86U
m98 AP23-AIND1 N132 VDD VDD P L=0.18U W=8.52U
m99 N164 N132 VSS VSS N L=0.18U W=4.86U
.ENDS RA1SHHXP38
****
.SUBCKT RA1SHHXP38X A0 A1 A2 AGTPB AGTPT AY0 AY0_ OEI_ WEI XP_0 XP_1 XP_2 XP_3
+  XP_4 XP_5 XP_6 XP_7 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3
** RA1SHHXP38X: 192 flat devices **
XI0_0 A0 A1 A2 A0 A1 A2 AGTPB AGTPT VSS VSS VSS AY0 AY0_ OEI_ WEI XP_0 XP_1
+  XP_2 XP_3 XP_4 XP_5 XP_6 XP_7 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2
+  YP1_3 RA1SHHXP38
.ENDS RA1SHHXP38X
****
.SUBCKT RA1SHX_PRE_DECODE A0 A0_0 A1 A1_0 A2 AGTPB AGTPT AY0 AY0_ OEI_ WEI
+  XP_0 XP_0_0 XP_1 XP_1_0 XP_2 XP_2_0 XP_3 XP_3_0 XP_4 XP_5 XP_6 XP_7 YP0_0
+  YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3
** RA1SHX_PRE_DECODE: 292 flat devices **
XI0_0 A0_0 A1_0 AGTPB AGTPT AY0 AY0_ OEI_ WEI XP_0_0 XP_1_0 XP_2_0 XP_3_0
+  YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 RA1SHHXP24X
XI1_0 A0 A1 A2 AGTPB AGTPT AY0 AY0_ OEI_ WEI XP_0 XP_1 XP_2 XP_3 XP_4 XP_5
+  XP_6 XP_7 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 RA1SHHXP38X
.ENDS RA1SHX_PRE_DECODE
****
.SUBCKT RA1SHHYP38 A0 A1 A2 ACONN0 ACONN1 ACONN2 AGTPB AGTPT AMX0 AMX1 AMX2
+  AY0 AY0_ OEI_ WEI YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3
** RA1SHHYP38: 192 flat devices **
d175 VSS ACONN2 DN 0.36P 2.4U
d176 VSS A2 DN 0.36P 2.4U
d183 VSS ACONN1 DN 0.36P 2.4U
d184 VSS A1 DN 0.36P 2.4U
d191 VSS ACONN0 DN 0.36P 2.4U
d192 VSS A0 DN 0.36P 2.4U
m1 AP67-APN1 N45 AP67-AIND1 VSS N L=0.18U W=4.84U
m10 N40 AI2_ VSS VSS N L=0.18U W=2.26U
m100 AP23-AIND1 N123 VDD VDD P L=0.18U W=8.52U
m101 N155 N123 N156 VSS N L=0.18U W=4.86U
m102 AP23-AIND1 AP23-AIN21 VDD VDD P L=0.18U W=8.52U
m103 AP23-AIND1 AP23-AIN21 N155 VSS N L=0.18U W=4.86U
m104 AP23-APN0 N140 AP23-AIND0 VSS N L=0.18U W=4.84U
m105 AP23-APN0 AGTPB AP23-AIND0 VDD P L=0.18U W=8.54U
m106 N140 AGTPB VDD VDD P L=0.18U W=1.16U
m107 N140 AGTPB VSS VSS N L=0.18U W=0.72U
m108 AP23-AIN20 AI0 VDD VDD P L=0.18U W=4.82U
m109 AP23-AIN20 AI0 VSS VSS N L=0.18U W=2.26U
m11 N74 N40 VSS VSS N L=0.18U W=4.86U
m110 N162 N124 VSS VSS N L=0.18U W=4.86U
m111 N161 N123 N162 VSS N L=0.18U W=4.86U
m112 AP23-AIND0 AP23-AIN20 N161 VSS N L=0.18U W=4.86U
m113 AP23-AIND0 N124 VDD VDD P L=0.18U W=8.52U
m114 N160 N124 VSS VSS N L=0.18U W=4.86U
m115 AP23-AIND0 N123 VDD VDD P L=0.18U W=8.52U
m116 N159 N123 N160 VSS N L=0.18U W=4.86U
m117 AP23-AIND0 AP23-AIN20 VDD VDD P L=0.18U W=8.52U
m118 AP23-AIND0 AP23-AIN20 N159 VSS N L=0.18U W=4.86U
m119 AP23-APN1 YP0_3 VDD VDD P L=0.28U W=0.24U
m12 N73 N39 N74 VSS N L=0.18U W=4.86U
m120 AP23-APN1 YP0_3 VSS VSS N L=0.54U W=0.24U
m121 YP0_3 AP23-APN1 VDD VDD P L=0.18U W=25U
m122 YP0_3 AP23-APN1 VSS VSS N L=0.18U W=9U
m123 AP23-APN0 YP0_2 VDD VDD P L=0.28U W=0.24U
m124 AP23-APN0 YP0_2 VSS VSS N L=0.54U W=0.24U
m125 YP0_2 AP23-APN0 VDD VDD P L=0.18U W=25U
m126 YP0_2 AP23-APN0 VSS VSS N L=0.18U W=9U
m127 AP01-APN1 N171 AP01-AIND1 VSS N L=0.18U W=4.84U
m128 AP01-APN1 AGTPT AP01-AIND1 VDD P L=0.18U W=8.54U
m129 N171 AGTPT VDD VDD P L=0.18U W=1.16U
m13 AP67-AIND1 AP67-AIN21 N73 VSS N L=0.18U W=4.86U
m130 N171 AGTPT VSS VSS N L=0.18U W=0.72U
m131 AP01-AIN21 AI0_ VDD VDD P L=0.18U W=4.82U
m132 AP01-AIN21 AI0_ VSS VSS N L=0.18U W=2.26U
m133 N165 AI1 VDD VDD P L=0.18U W=4.82U
m134 N165 AI1 VSS VSS N L=0.18U W=2.26U
m135 N166 AI2 VDD VDD P L=0.18U W=4.82U
m136 N166 AI2 VSS VSS N L=0.18U W=2.26U
m137 N200 N166 VSS VSS N L=0.18U W=4.86U
m138 N199 N165 N200 VSS N L=0.18U W=4.86U
m139 AP01-AIND1 AP01-AIN21 N199 VSS N L=0.18U W=4.86U
m14 AP67-AIND1 N40 VDD VDD P L=0.18U W=8.52U
m140 AP01-AIND1 N166 VDD VDD P L=0.18U W=8.52U
m141 N198 N166 VSS VSS N L=0.18U W=4.86U
m142 AP01-AIND1 N165 VDD VDD P L=0.18U W=8.52U
m143 N197 N165 N198 VSS N L=0.18U W=4.86U
m144 AP01-AIND1 AP01-AIN21 VDD VDD P L=0.18U W=8.52U
m145 AP01-AIND1 AP01-AIN21 N197 VSS N L=0.18U W=4.86U
m146 AP01-APN0 N182 AP01-AIND0 VSS N L=0.18U W=4.84U
m147 AP01-APN0 AGTPB AP01-AIND0 VDD P L=0.18U W=8.54U
m148 N182 AGTPB VDD VDD P L=0.18U W=1.16U
m149 N182 AGTPB VSS VSS N L=0.18U W=0.72U
m15 N72 N40 VSS VSS N L=0.18U W=4.86U
m150 AP01-AIN20 AI0 VDD VDD P L=0.18U W=4.82U
m151 AP01-AIN20 AI0 VSS VSS N L=0.18U W=2.26U
m152 N204 N166 VSS VSS N L=0.18U W=4.86U
m153 N203 N165 N204 VSS N L=0.18U W=4.86U
m154 AP01-AIND0 AP01-AIN20 N203 VSS N L=0.18U W=4.86U
m155 AP01-AIND0 N166 VDD VDD P L=0.18U W=8.52U
m156 N202 N166 VSS VSS N L=0.18U W=4.86U
m157 AP01-AIND0 N165 VDD VDD P L=0.18U W=8.52U
m158 N201 N165 N202 VSS N L=0.18U W=4.86U
m159 AP01-AIND0 AP01-AIN20 VDD VDD P L=0.18U W=8.52U
m16 AP67-AIND1 N39 VDD VDD P L=0.18U W=8.52U
m160 AP01-AIND0 AP01-AIN20 N201 VSS N L=0.18U W=4.86U
m161 AP01-APN1 YP0_1 VDD VDD P L=0.28U W=0.24U
m162 AP01-APN1 YP0_1 VSS VSS N L=0.54U W=0.24U
m163 YP0_1 AP01-APN1 VDD VDD P L=0.18U W=25U
m164 YP0_1 AP01-APN1 VSS VSS N L=0.18U W=9U
m165 AP01-APN0 YP0_0 VDD VDD P L=0.28U W=0.24U
m166 AP01-APN0 YP0_0 VSS VSS N L=0.54U W=0.24U
m167 YP0_0 AP01-APN0 VDD VDD P L=0.18U W=25U
m168 YP0_0 AP01-APN0 VSS VSS N L=0.18U W=9U
m169 AI2 N205 VDD VDD P L=0.18U W=6.72U
m17 N71 N39 N72 VSS N L=0.18U W=4.86U
m170 AI2 N205 VSS VSS N L=0.18U W=3.22U
m171 AI2_ ACONN2 VDD VDD P L=0.18U W=6.72U
m172 AI2_ ACONN2 VSS VSS N L=0.18U W=3.22U
m173 N205 ACONN2 VDD VDD P L=0.18U W=5.36U
m174 N205 ACONN2 VSS VSS N L=0.18U W=2.56U
m177 AI1 N214 VDD VDD P L=0.18U W=6.72U
m178 AI1 N214 VSS VSS N L=0.18U W=3.22U
m179 AI1_ ACONN1 VDD VDD P L=0.18U W=6.72U
m18 AP67-AIND1 AP67-AIN21 VDD VDD P L=0.18U W=8.52U
m180 AI1_ ACONN1 VSS VSS N L=0.18U W=3.22U
m181 N214 ACONN1 VDD VDD P L=0.18U W=5.36U
m182 N214 ACONN1 VSS VSS N L=0.18U W=2.56U
m185 AI0 N223 VDD VDD P L=0.18U W=6.72U
m186 AI0 N223 VSS VSS N L=0.18U W=3.22U
m187 AI0_ ACONN0 VDD VDD P L=0.18U W=6.72U
m188 AI0_ ACONN0 VSS VSS N L=0.18U W=3.22U
m189 N223 ACONN0 VDD VDD P L=0.18U W=5.36U
m19 AP67-AIND1 AP67-AIN21 N71 VSS N L=0.18U W=4.86U
m190 N223 ACONN0 VSS VSS N L=0.18U W=2.56U
m2 AP67-APN1 AGTPT AP67-AIND1 VDD P L=0.18U W=8.54U
m20 AP67-APN0 N56 AP67-AIND0 VSS N L=0.18U W=4.84U
m21 AP67-APN0 AGTPB AP67-AIND0 VDD P L=0.18U W=8.54U
m22 N56 AGTPB VDD VDD P L=0.18U W=1.16U
m23 N56 AGTPB VSS VSS N L=0.18U W=0.72U
m24 AP67-AIN20 AI0 VDD VDD P L=0.18U W=4.82U
m25 AP67-AIN20 AI0 VSS VSS N L=0.18U W=2.26U
m26 N78 N40 VSS VSS N L=0.18U W=4.86U
m27 N77 N39 N78 VSS N L=0.18U W=4.86U
m28 AP67-AIND0 AP67-AIN20 N77 VSS N L=0.18U W=4.86U
m29 AP67-AIND0 N40 VDD VDD P L=0.18U W=8.52U
m3 N45 AGTPT VDD VDD P L=0.18U W=1.16U
m30 N76 N40 VSS VSS N L=0.18U W=4.86U
m31 AP67-AIND0 N39 VDD VDD P L=0.18U W=8.52U
m32 N75 N39 N76 VSS N L=0.18U W=4.86U
m33 AP67-AIND0 AP67-AIN20 VDD VDD P L=0.18U W=8.52U
m34 AP67-AIND0 AP67-AIN20 N75 VSS N L=0.18U W=4.86U
m35 AP67-APN1 YP1_3 VDD VDD P L=0.28U W=0.24U
m36 AP67-APN1 YP1_3 VSS VSS N L=0.54U W=0.24U
m37 YP1_3 AP67-APN1 VDD VDD P L=0.18U W=25U
m38 YP1_3 AP67-APN1 VSS VSS N L=0.18U W=9U
m39 AP67-APN0 YP1_2 VDD VDD P L=0.28U W=0.24U
m4 N45 AGTPT VSS VSS N L=0.18U W=0.72U
m40 AP67-APN0 YP1_2 VSS VSS N L=0.54U W=0.24U
m41 YP1_2 AP67-APN0 VDD VDD P L=0.18U W=25U
m42 YP1_2 AP67-APN0 VSS VSS N L=0.18U W=9U
m43 AP45-APN1 N87 AP45-AIND1 VSS N L=0.18U W=4.84U
m44 AP45-APN1 AGTPT AP45-AIND1 VDD P L=0.18U W=8.54U
m45 N87 AGTPT VDD VDD P L=0.18U W=1.16U
m46 N87 AGTPT VSS VSS N L=0.18U W=0.72U
m47 AP45-AIN21 AI0_ VDD VDD P L=0.18U W=4.82U
m48 AP45-AIN21 AI0_ VSS VSS N L=0.18U W=2.26U
m49 N81 AI1 VDD VDD P L=0.18U W=4.82U
m5 AP67-AIN21 AI0_ VDD VDD P L=0.18U W=4.82U
m50 N81 AI1 VSS VSS N L=0.18U W=2.26U
m51 N82 AI2_ VDD VDD P L=0.18U W=4.82U
m52 N82 AI2_ VSS VSS N L=0.18U W=2.26U
m53 N116 N82 VSS VSS N L=0.18U W=4.86U
m54 N115 N81 N116 VSS N L=0.18U W=4.86U
m55 AP45-AIND1 AP45-AIN21 N115 VSS N L=0.18U W=4.86U
m56 AP45-AIND1 N82 VDD VDD P L=0.18U W=8.52U
m57 N114 N82 VSS VSS N L=0.18U W=4.86U
m58 AP45-AIND1 N81 VDD VDD P L=0.18U W=8.52U
m59 N113 N81 N114 VSS N L=0.18U W=4.86U
m6 AP67-AIN21 AI0_ VSS VSS N L=0.18U W=2.26U
m60 AP45-AIND1 AP45-AIN21 VDD VDD P L=0.18U W=8.52U
m61 AP45-AIND1 AP45-AIN21 N113 VSS N L=0.18U W=4.86U
m62 AP45-APN0 N98 AP45-AIND0 VSS N L=0.18U W=4.84U
m63 AP45-APN0 AGTPB AP45-AIND0 VDD P L=0.18U W=8.54U
m64 N98 AGTPB VDD VDD P L=0.18U W=1.16U
m65 N98 AGTPB VSS VSS N L=0.18U W=0.72U
m66 AP45-AIN20 AI0 VDD VDD P L=0.18U W=4.82U
m67 AP45-AIN20 AI0 VSS VSS N L=0.18U W=2.26U
m68 N120 N82 VSS VSS N L=0.18U W=4.86U
m69 N119 N81 N120 VSS N L=0.18U W=4.86U
m7 N39 AI1_ VDD VDD P L=0.18U W=4.82U
m70 AP45-AIND0 AP45-AIN20 N119 VSS N L=0.18U W=4.86U
m71 AP45-AIND0 N82 VDD VDD P L=0.18U W=8.52U
m72 N118 N82 VSS VSS N L=0.18U W=4.86U
m73 AP45-AIND0 N81 VDD VDD P L=0.18U W=8.52U
m74 N117 N81 N118 VSS N L=0.18U W=4.86U
m75 AP45-AIND0 AP45-AIN20 VDD VDD P L=0.18U W=8.52U
m76 AP45-AIND0 AP45-AIN20 N117 VSS N L=0.18U W=4.86U
m77 AP45-APN1 YP1_1 VDD VDD P L=0.28U W=0.24U
m78 AP45-APN1 YP1_1 VSS VSS N L=0.54U W=0.24U
m79 YP1_1 AP45-APN1 VDD VDD P L=0.18U W=25U
m8 N39 AI1_ VSS VSS N L=0.18U W=2.26U
m80 YP1_1 AP45-APN1 VSS VSS N L=0.18U W=9U
m81 AP45-APN0 YP1_0 VDD VDD P L=0.28U W=0.24U
m82 AP45-APN0 YP1_0 VSS VSS N L=0.54U W=0.24U
m83 YP1_0 AP45-APN0 VDD VDD P L=0.18U W=25U
m84 YP1_0 AP45-APN0 VSS VSS N L=0.18U W=9U
m85 AP23-APN1 N129 AP23-AIND1 VSS N L=0.18U W=4.84U
m86 AP23-APN1 AGTPT AP23-AIND1 VDD P L=0.18U W=8.54U
m87 N129 AGTPT VDD VDD P L=0.18U W=1.16U
m88 N129 AGTPT VSS VSS N L=0.18U W=0.72U
m89 AP23-AIN21 AI0_ VDD VDD P L=0.18U W=4.82U
m9 N40 AI2_ VDD VDD P L=0.18U W=4.82U
m90 AP23-AIN21 AI0_ VSS VSS N L=0.18U W=2.26U
m91 N123 AI1_ VDD VDD P L=0.18U W=4.82U
m92 N123 AI1_ VSS VSS N L=0.18U W=2.26U
m93 N124 AI2 VDD VDD P L=0.18U W=4.82U
m94 N124 AI2 VSS VSS N L=0.18U W=2.26U
m95 N158 N124 VSS VSS N L=0.18U W=4.86U
m96 N157 N123 N158 VSS N L=0.18U W=4.86U
m97 AP23-AIND1 AP23-AIN21 N157 VSS N L=0.18U W=4.86U
m98 AP23-AIND1 N124 VDD VDD P L=0.18U W=8.52U
m99 N156 N124 VSS VSS N L=0.18U W=4.86U
.ENDS RA1SHHYP38
****
.SUBCKT RA1SHHYP38X A0 A1 A2 AGTPB AGTPT AY0 AY0_ IO IO_1 IO_3 IO_5 IO_7 IO_9
+  OEI_ WEI YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3
** RA1SHHYP38X: 192 flat devices **
XI0_0 A0 A1 A2 A0 A1 A2 AGTPB AGTPT VSS VSS VSS AY0 AY0_ OEI_ WEI YP0_0 YP0_1
+  YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 RA1SHHYP38
.ENDS RA1SHHYP38X
****
.SUBCKT RA1SHHYP12R A0 ACONN0 AGTP AMX0 AY0 AY0_ CLK GSRCN GTPN OEI_ RST WEI
+  YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3
** RA1SHHYP12R: 50 flat devices **
d7 VSS ACONN0 DN 0.36P 2.4U
d8 VSS A0 DN 0.36P 2.4U
m1 N24 N27 VDD VDD P L=0.18U W=6.72U
m10 AP01-APN1 AGTP AP01-AIND1 VDD P L=0.18U W=8.54U
m11 N44 AGTP VDD VDD P L=0.18U W=1.16U
m12 N44 AGTP VSS VSS N L=0.18U W=0.72U
m13 AP01-AIN21 N24 VDD VDD P L=0.18U W=4.82U
m14 AP01-AIN21 N24 VSS VSS N L=0.18U W=2.26U
m15 N38 VSS VDD VDD P L=0.18U W=4.82U
m16 N38 VSS VSS VSS N L=0.18U W=2.26U
m17 N39 VSS VDD VDD P L=0.18U W=4.82U
m18 N39 VSS VSS VSS N L=0.18U W=2.26U
m19 N73 N39 VSS VSS N L=0.18U W=4.86U
m2 N24 N27 VSS VSS N L=0.18U W=3.22U
m20 N72 N38 N73 VSS N L=0.18U W=4.86U
m21 AP01-AIND1 AP01-AIN21 N72 VSS N L=0.18U W=4.86U
m22 AP01-AIND1 N39 VDD VDD P L=0.18U W=8.52U
m23 N71 N39 VSS VSS N L=0.18U W=4.86U
m24 AP01-AIND1 N38 VDD VDD P L=0.18U W=8.52U
m25 N70 N38 N71 VSS N L=0.18U W=4.86U
m26 AP01-AIND1 AP01-AIN21 VDD VDD P L=0.18U W=8.52U
m27 AP01-AIND1 AP01-AIN21 N70 VSS N L=0.18U W=4.86U
m28 AP01-APN0 N55 AP01-AIND0 VSS N L=0.18U W=4.84U
m29 AP01-APN0 AGTP AP01-AIND0 VDD P L=0.18U W=8.54U
m3 N23 ACONN0 VDD VDD P L=0.18U W=6.72U
m30 N55 AGTP VDD VDD P L=0.18U W=1.16U
m31 N55 AGTP VSS VSS N L=0.18U W=0.72U
m32 AP01-AIN20 N23 VDD VDD P L=0.18U W=4.82U
m33 AP01-AIN20 N23 VSS VSS N L=0.18U W=2.26U
m34 N77 N39 VSS VSS N L=0.18U W=4.86U
m35 N76 N38 N77 VSS N L=0.18U W=4.86U
m36 AP01-AIND0 AP01-AIN20 N76 VSS N L=0.18U W=4.86U
m37 AP01-AIND0 N39 VDD VDD P L=0.18U W=8.52U
m38 N75 N39 VSS VSS N L=0.18U W=4.86U
m39 AP01-AIND0 N38 VDD VDD P L=0.18U W=8.52U
m4 N23 ACONN0 VSS VSS N L=0.18U W=3.22U
m40 N74 N38 N75 VSS N L=0.18U W=4.86U
m41 AP01-AIND0 AP01-AIN20 VDD VDD P L=0.18U W=8.52U
m42 AP01-AIND0 AP01-AIN20 N74 VSS N L=0.18U W=4.86U
m43 AP01-APN1 AY0_ VDD VDD P L=0.28U W=0.24U
m44 AP01-APN1 AY0_ VSS VSS N L=0.54U W=0.24U
m45 AY0_ AP01-APN1 VDD VDD P L=0.18U W=25U
m46 AY0_ AP01-APN1 VSS VSS N L=0.18U W=9U
m47 AP01-APN0 AY0 VDD VDD P L=0.28U W=0.24U
m48 AP01-APN0 AY0 VSS VSS N L=0.54U W=0.24U
m49 AY0 AP01-APN0 VDD VDD P L=0.18U W=25U
m5 N27 ACONN0 VDD VDD P L=0.18U W=5.36U
m50 AY0 AP01-APN0 VSS VSS N L=0.18U W=9U
m6 N27 ACONN0 VSS VSS N L=0.18U W=2.56U
m9 AP01-APN1 N44 AP01-AIND1 VSS N L=0.18U W=4.84U
.ENDS RA1SHHYP12R
****
.SUBCKT RA1SHHYP12RX A0 AGTP AY0 AY0_ CLK GSRCN GTPN IO IO_1 OEI_ RST WEI
+  YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3
** RA1SHHYP12RX: 50 flat devices **
XI0_0 A0 A0 AGTP VSS AY0 AY0_ CLK GSRCN GTPN OEI_ RST WEI YP0_0 YP0_1 YP0_2
+  YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 RA1SHHYP12R
.ENDS RA1SHHYP12RX
****
.SUBCKT RA1SHY_DECODE A0 A0_0 A1 A2 AGTP AY0 AY0_ CLK GSRCN GTPN OEI_ RST WEI
+  YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3
** RA1SHY_DECODE: 242 flat devices **
XI0_0 A0_0 A1 A2 AGTP AGTP AY0 AY0_ IO IO_1 IO_3 IO_5 IO_7 IO_9 OEI_ WEI YP0_0
+  YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 RA1SHHYP38X
XI1_0 A0 AGTP AY0 AY0_ CLK GSRCN GTPN IO_6 IO_1_8 OEI_ RST WEI YP0_0 YP0_1
+  YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 RA1SHHYP12RX
.ENDS RA1SHY_DECODE
****
.SUBCKT RA1SHHBF8 CEMX CEN CENI_ CEN_ CLK GSRCN GTP GTPN MBL OEI_ OEMX OEN
+  OENI_ OEN_ RST STOV TMS WEI WEMX WEN WENI_ WEN_
** RA1SHHBF8: 96 flat devices **
d50 VSS CLK DN 0.36P 2.4U
d51 VSS STOV DN 0.36P 2.4U
d62 VSS WEN DN 0.36P 2.4U
d65 VSS OEN DN 0.36P 2.4U
d68 VSS CEN DN 0.36P 2.4U
d71 VSS TMS DN 0.36P 2.4U
d92 VSS WEN DN 0.36P 2.4U
d93 VSS OEN DN 0.36P 2.4U
d94 VSS CEN DN 0.36P 2.4U
d95 VSS STOV DN 0.36P 2.4U
d96 VSS CLK DN 0.36P 2.4U
m1 WEI N41 VDD VDD P L=0.18U W=13.28U
m10 BF-CLKN CLK VSS VSS N L=0.36U W=2.08U
m11 N41 BF-TMS_ VDD VDD P L=0.18U W=6.02U
m12 N94 BF-TMS_ VSS VSS N L=0.18U W=4.38U
m13 N41 WENI_ VDD VDD P L=0.18U W=6.02U
m14 N41 WENI_ N94 VSS N L=0.18U W=4.38U
m15 BF-TMS_ TMS VDD VDD P L=0.18U W=3.04U
m16 BF-TMS_ TMS VSS VSS N L=0.18U W=1.52U
m17 OEI_ N54 VDD VDD P L=0.18U W=16.84U
m18 OEI_ N54 VSS VSS N L=0.18U W=8.42U
m19 N54 N57 VDD VDD P L=0.18U W=6.32U
m2 WEI N41 VSS VSS N L=0.18U W=6.64U
m20 N54 N57 VSS VSS N L=0.18U W=3.16U
m21 N57 BF-TMS_ VDD VDD P L=0.18U W=2.5U
m22 N95 BF-TMS_ VSS VSS N L=0.18U W=2.38U
m23 N57 OENI_ VDD VDD P L=0.18U W=2.5U
m24 N57 OENI_ N95 VSS N L=0.18U W=2.38U
m25 N97 GTP VSS VSS N L=0.18U W=3.98U
m26 BF-RSRCN BF-CKSTOV N97 VSS N L=0.18U W=3.98U
m27 BF-RSRCN GTP VDD VDD P L=0.18U W=8.74U
m28 N96 GTP VSS VSS N L=0.18U W=3.98U
m29 BF-RSRCN BF-CKSTOV VDD VDD P L=0.18U W=8.74U
m3 BF-CENMML BF-CLKN N93 VDD P L=0.18U W=0.24U
m30 BF-RSRCN BF-CKSTOV N96 VSS N L=0.18U W=3.98U
m31 BF-RSTSRC BF-RSRCN VDD VDD P L=0.18U W=21.28U
m32 BF-RSTSRC BF-RSRCN VSS VSS N L=0.18U W=9.68U
m33 BF-CKSTOV STOV VDD VDD P L=0.18U W=4.18U
m34 N98 STOV VSS VSS N L=0.18U W=3.8U
m35 BF-CKSTOV CLK VDD VDD P L=0.18U W=4.18U
m36 BF-CKSTOV CLK N98 VSS N L=0.18U W=3.8U
m37 GTPN BF-GTPI N68 VSS N L=0.18U W=0.24U
m38 N34 N34 VDD VDD P L=0.18U W=0.24U
m39 GTPN BF-GTPI VDD VDD P L=0.18U W=0.24U
m4 N93 BF-CEL VDD VDD P L=0.18U W=0.24U
m40 N34 VDD VDD VDD P L=0.18U W=0.24U
m41 BF-GTPI GTPN VDD VDD P L=0.18U W=0.48U
m42 BF-GTPI GTPN VSS VSS N L=0.18U W=0.24U
m43 N68 N34 VSS VSS N L=0.18U W=0.24U
m44 N100 BF-CLKN VSS VSS N L=0.18U W=4.78U
m45 GSRCN BF-CEL N100 VSS N L=0.18U W=4.78U
m46 GSRCN BF-CLKN VDD VDD P L=0.18U W=8.4U
m47 N99 BF-CLKN VSS VSS N L=0.18U W=4.78U
m48 GSRCN BF-CEL VDD VDD P L=0.18U W=8.4U
m49 GSRCN BF-CEL N99 VSS N L=0.18U W=4.78U
m5 BF-CENMML CLK N92 VSS N L=0.18U W=0.24U
m52 N77 BF-CLKN VSS VSS N L=0.18U W=1.24U
m53 N79 CLK VDD VDD P L=0.18U W=3.26U
m54 BF-CENMML CENI_ N81 VDD P L=0.18U W=3.26U
m55 BF-CENMML CENI_ N77 VSS N L=0.18U W=1.24U
m56 N81 TMS N79 VDD P L=0.18U W=3.26U
m57 BF-CENMML TMS N77 VSS N L=0.18U W=1.24U
m58 RST BF-MBLN VDD VDD P L=0.18U W=3.6U
m59 RST BF-RSTSRC VDD VDD P L=0.18U W=33.44U
m6 N92 BF-CEL VSS VSS N L=0.18U W=0.24U
m60 BF-MBLN MBL VDD VDD P L=0.18U W=13.24U
m61 BF-MBLN MBL VSS VSS N L=0.18U W=4.3U
m63 WEN_ WEN VDD VDD P L=0.18U W=3.12U
m64 WEN_ WEN VSS VSS N L=0.18U W=1.48U
m66 OEN_ OEN VDD VDD P L=0.18U W=1.34U
m67 OEN_ OEN VSS VSS N L=0.18U W=0.64U
m69 CEN_ CEN VDD VDD P L=0.18U W=3.92U
m7 BF-CEL BF-CENMML VDD VDD P L=0.18U W=3.88U
m70 CEN_ CEN VSS VSS N L=0.18U W=1.86U
m72 RST BF-MBLN N116 VSS N L=0.18U W=3.96U
m73 N116 BF-RSTSRC VSS VSS N L=0.18U W=5.14U
m74 RST BF-MBLN N115 VSS N L=0.18U W=3.96U
m75 N115 BF-RSTSRC VSS VSS N L=0.18U W=5.14U
m76 RST BF-MBLN N114 VSS N L=0.18U W=3.96U
m77 N114 BF-RSTSRC VSS VSS N L=0.18U W=5.14U
m78 RST BF-MBLN N113 VSS N L=0.18U W=3.96U
m79 N113 BF-RSTSRC VSS VSS N L=0.18U W=5.14U
m8 BF-CEL BF-CENMML VSS VSS N L=0.18U W=1.96U
m80 RST BF-MBLN N112 VSS N L=0.18U W=3.96U
m81 N112 BF-RSTSRC VSS VSS N L=0.18U W=5.14U
m82 RST BF-MBLN N111 VSS N L=0.18U W=3.96U
m83 N111 BF-RSTSRC VSS VSS N L=0.18U W=5.14U
m84 RST BF-MBLN N110 VSS N L=0.18U W=3.96U
m85 N110 BF-RSTSRC VSS VSS N L=0.18U W=5.14U
m86 RST BF-MBLN N109 VSS N L=0.18U W=3.96U
m87 N109 BF-RSTSRC VSS VSS N L=0.18U W=5.14U
m88 RST BF-MBLN N108 VSS N L=0.18U W=3.96U
m89 N108 BF-RSTSRC VSS VSS N L=0.18U W=5.14U
m9 BF-CLKN CLK VDD VDD P L=0.18U W=4.56U
m90 RST BF-MBLN N107 VSS N L=0.18U W=3.96U
m91 N107 BF-RSTSRC VSS VSS N L=0.18U W=5.14U
.ENDS RA1SHHBF8
****
.SUBCKT RA1SHHBFX CEN CENI_ CLK GSRCN GTP GTPN IO IO_1 IO_3 IO_5 IO_7 IO_9
+  IO_11 IO_16 MBL OEI_ OEN OENI_ RST WEI WEN WENI_
** RA1SHHBFX: 96 flat devices **
XI0_0 VSS CEN CENI_ CENI_ CLK GSRCN GTP GTPN MBL OEI_ VSS OEN OENI_ OENI_ RST
+  VSS VSS WEI VSS WEN WENI_ WENI_ RA1SHHBF8
.ENDS RA1SHHBFX
****
.SUBCKT RA1SHCCMWP BL BL_ MWLB MWLT MWPB MWPT
** RA1SHCCMWP: 8 flat devices **
m1 BL MWPB CORED VSS N L=0.235U W=0.21U
m2 BL_ MWPB CORED_ VSS N L=0.235U W=0.21U
m3 BL MWPT CORED VSS N L=0.235U W=0.21U
m4 BL_ MWPT CORED_ VSS N L=0.235U W=0.21U
m5 VSS VSS CORED VSS N L=0.18U W=0.42U
m6 VSS VSS CORED_ VSS N L=0.18U W=0.42U
m7 VSS VSS CORED VSS N L=0.18U W=0.42U
m8 VSS VSS CORED_ VSS N L=0.18U W=0.42U
.ENDS RA1SHCCMWP
****
.SUBCKT RA1SHMODEL_ROW_6 BL BL0 BL0_ BL1 BL1_ BL_ BL_0 BL_1 BL_2 BL_3 BL_4
+  BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 BL_16 BL_17
+  BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24 BL_25 BL_26 BL_27 BL_28 BL_29
+  BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36 BL_37 BL_38 BL_39 BL_40 BL_41
+  BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48 BL_49 BL_50 BL_51 BL_52 BL_53
+  BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60 BL_61 BL_62 BL_63 BL_64 BL_65
+  BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72 BL_73 BL_74 BL_75 BL_76 BL_77
+  BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84 BL_85 BL_86 BL_87 BL_88 BL_89
+  BL_90 BL_91 BL_92 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19
+  BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29
+  BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39
+  BL__40 BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49
+  BL__50 BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59
+  BL__60 BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69
+  BL__70 BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79
+  BL__80 BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89
+  BL__90 BL__91 BL__92 MWLB MWPB MWPT WL
** RA1SHMODEL_ROW_6: 1328 flat devices **
XI0_0 BL_92 BL__92 MWLB MWLB MWPB MWPT RA1SHCCMWG
XI0_2 BL_92 BL__92 WL WL RA1SHCCG
XI100_0 BL BL_ VSS VSS VSS VSS RA1SHCCMWG
XI100_2 BL BL_ WL WL RA1SHCCG
XI10_0 BL_82 BL__82 MWLB MWLB MWPB MWPT RA1SHCCMWP
XI10_2 BL_82 BL__82 WL WL RA1SHCCP
XI11_0 BL_81 BL__81 MWLB MWLB MWPB MWPT RA1SHCCMWG
XI11_2 BL_81 BL__81 WL WL RA1SHCCG
XI12_0 BL_80 BL__80 MWLB MWLB MWPB MWPT RA1SHCCMWG
XI12_2 BL_80 BL__80 WL WL RA1SHCCG
XI13_0 BL_79 BL__79 MWLB MWLB MWPB MWPT RA1SHCCMWP
XI13_2 BL_79 BL__79 WL WL RA1SHCCP
XI14_0 BL_78 BL__78 MWLB MWLB MWPB MWPT RA1SHCCMWP
XI14_2 BL_78 BL__78 WL WL RA1SHCCP
XI15_0 BL_77 BL__77 MWLB MWLB MWPB MWPT RA1SHCCMWG
XI15_2 BL_77 BL__77 WL WL RA1SHCCG
XI17_0 BL_76 BL__76 MWLB MWLB MWLB MWLB RA1SHCCMWG
XI17_2 BL_76 BL__76 WL WL RA1SHCCG
XI18_0 BL_75 BL__75 MWLB MWLB MWLB MWLB RA1SHCCMWP
XI18_2 BL_75 BL__75 WL WL RA1SHCCP
XI19_0 BL_74 BL__74 MWLB MWLB MWLB MWLB RA1SHCCMWP
XI19_2 BL_74 BL__74 WL WL RA1SHCCP
XI1_0 BL_91 BL__91 MWLB MWLB MWPB MWPT RA1SHCCMWP
XI1_2 BL_91 BL__91 WL WL RA1SHCCP
XI20_0 BL_73 BL__73 MWLB MWLB MWLB MWLB RA1SHCCMWG
XI20_2 BL_73 BL__73 WL WL RA1SHCCG
XI21_0 BL_72 BL__72 MWLB MWLB MWLB MWLB RA1SHCCMWG
XI21_2 BL_72 BL__72 WL WL RA1SHCCG
XI22_0 BL_71 BL__71 MWLB MWLB MWLB MWLB RA1SHCCMWP
XI22_2 BL_71 BL__71 WL WL RA1SHCCP
XI23_0 BL_70 BL__70 MWLB MWLB MWLB MWLB RA1SHCCMWP
XI23_2 BL_70 BL__70 WL WL RA1SHCCP
XI24_0 BL_69 BL__69 MWLB MWLB MWLB MWLB RA1SHCCMWG
XI24_2 BL_69 BL__69 WL WL RA1SHCCG
XI25_0 BL_68 BL__68 MWLB MWLB MWLB MWLB RA1SHCCMWG
XI25_2 BL_68 BL__68 WL WL RA1SHCCG
XI26_0 BL_67 BL__67 MWLB MWLB MWLB MWLB RA1SHCCMWP
XI26_2 BL_67 BL__67 WL WL RA1SHCCP
XI27_0 BL_66 BL__66 MWLB MWLB MWLB MWLB RA1SHCCMWP
XI27_2 BL_66 BL__66 WL WL RA1SHCCP
XI28_0 BL_65 BL__65 MWLB MWLB MWLB MWLB RA1SHCCMWG
XI28_2 BL_65 BL__65 WL WL RA1SHCCG
XI29_0 BL_64 BL__64 MWLB MWLB MWLB MWLB RA1SHCCMWG
XI29_2 BL_64 BL__64 WL WL RA1SHCCG
XI2_0 BL_90 BL__90 MWLB MWLB MWPB MWPT RA1SHCCMWP
XI2_2 BL_90 BL__90 WL WL RA1SHCCP
XI30_0 BL_63 BL__63 MWLB MWLB MWLB MWLB RA1SHCCMWP
XI30_2 BL_63 BL__63 WL WL RA1SHCCP
XI31_0 BL_62 BL__62 MWLB MWLB MWLB MWLB RA1SHCCMWP
XI31_2 BL_62 BL__62 WL WL RA1SHCCP
XI32_0 BL_61 BL__61 MWLB MWLB MWLB MWLB RA1SHCCMWG
XI32_2 BL_61 BL__61 WL WL RA1SHCCG
XI34_0 BL_60 BL__60 MWLB MWLB MWLB MWLB RA1SHCCMWG
XI34_2 BL_60 BL__60 WL WL RA1SHCCG
XI35_0 BL_59 BL__59 MWLB MWLB MWLB MWLB RA1SHCCMWP
XI35_2 BL_59 BL__59 WL WL RA1SHCCP
XI36_0 BL_58 BL__58 MWLB MWLB MWLB MWLB RA1SHCCMWP
XI36_2 BL_58 BL__58 WL WL RA1SHCCP
XI37_0 BL_57 BL__57 MWLB MWLB MWLB MWLB RA1SHCCMWG
XI37_2 BL_57 BL__57 WL WL RA1SHCCG
XI38_0 BL_56 BL__56 MWLB MWLB MWLB MWLB RA1SHCCMWG
XI38_2 BL_56 BL__56 WL WL RA1SHCCG
XI39_0 BL_55 BL__55 MWLB MWLB MWLB MWLB RA1SHCCMWP
XI39_2 BL_55 BL__55 WL WL RA1SHCCP
XI3_0 BL_89 BL__89 MWLB MWLB MWPB MWPT RA1SHCCMWG
XI3_2 BL_89 BL__89 WL WL RA1SHCCG
XI40_0 BL_54 BL__54 MWLB MWLB MWLB MWLB RA1SHCCMWP
XI40_2 BL_54 BL__54 WL WL RA1SHCCP
XI41_0 BL_53 BL__53 MWLB MWLB MWLB MWLB RA1SHCCMWG
XI41_2 BL_53 BL__53 WL WL RA1SHCCG
XI42_0 BL_52 BL__52 MWLB MWLB MWLB MWLB RA1SHCCMWG
XI42_2 BL_52 BL__52 WL WL RA1SHCCG
XI43_0 BL_51 BL__51 MWLB MWLB MWLB MWLB RA1SHCCMWP
XI43_2 BL_51 BL__51 WL WL RA1SHCCP
XI44_0 BL_50 BL__50 MWLB MWLB MWLB MWLB RA1SHCCMWP
XI44_2 BL_50 BL__50 WL WL RA1SHCCP
XI45_0 BL_49 BL__49 MWLB MWLB MWLB MWLB RA1SHCCMWG
XI45_2 BL_49 BL__49 WL WL RA1SHCCG
XI46_0 BL_48 BL__48 MWLB MWLB MWLB MWLB RA1SHCCMWG
XI46_2 BL_48 BL__48 WL WL RA1SHCCG
XI47_0 BL_47 BL__47 MWLB MWLB MWLB MWLB RA1SHCCMWP
XI47_2 BL_47 BL__47 WL WL RA1SHCCP
XI48_0 BL_46 BL__46 MWLB MWLB MWLB MWLB RA1SHCCMWP
XI48_2 BL_46 BL__46 WL WL RA1SHCCP
XI49_0 BL_45 BL__45 MWLB MWLB MWLB MWLB RA1SHCCMWG
XI49_2 BL_45 BL__45 WL WL RA1SHCCG
XI4_0 BL_88 BL__88 MWLB MWLB MWPB MWPT RA1SHCCMWG
XI4_2 BL_88 BL__88 WL WL RA1SHCCG
XI51_2 BL0 BL0_ WL WL RA1SHCCG
XI52_2 BL1 BL1_ WL WL RA1SHCCP
XI53_0 BL_44 BL__44 VSS VSS VSS VSS RA1SHCCMWP
XI53_2 BL_44 BL__44 WL WL RA1SHCCP
XI54_0 BL_43 BL__43 VSS VSS VSS VSS RA1SHCCMWG
XI54_2 BL_43 BL__43 WL WL RA1SHCCG
XI55_0 BL_42 BL__42 VSS VSS VSS VSS RA1SHCCMWG
XI55_2 BL_42 BL__42 WL WL RA1SHCCG
XI56_0 BL_41 BL__41 VSS VSS VSS VSS RA1SHCCMWP
XI56_2 BL_41 BL__41 WL WL RA1SHCCP
XI57_0 BL_40 BL__40 VSS VSS VSS VSS RA1SHCCMWP
XI57_2 BL_40 BL__40 WL WL RA1SHCCP
XI58_0 BL_39 BL__39 VSS VSS VSS VSS RA1SHCCMWG
XI58_2 BL_39 BL__39 WL WL RA1SHCCG
XI59_0 BL_38 BL__38 VSS VSS VSS VSS RA1SHCCMWG
XI59_2 BL_38 BL__38 WL WL RA1SHCCG
XI5_0 BL_87 BL__87 MWLB MWLB MWPB MWPT RA1SHCCMWP
XI5_2 BL_87 BL__87 WL WL RA1SHCCP
XI60_0 BL_37 BL__37 VSS VSS VSS VSS RA1SHCCMWP
XI60_2 BL_37 BL__37 WL WL RA1SHCCP
XI61_0 BL_36 BL__36 VSS VSS VSS VSS RA1SHCCMWP
XI61_2 BL_36 BL__36 WL WL RA1SHCCP
XI62_0 BL_35 BL__35 VSS VSS VSS VSS RA1SHCCMWG
XI62_2 BL_35 BL__35 WL WL RA1SHCCG
XI63_0 BL_34 BL__34 VSS VSS VSS VSS RA1SHCCMWG
XI63_2 BL_34 BL__34 WL WL RA1SHCCG
XI64_0 BL_33 BL__33 VSS VSS VSS VSS RA1SHCCMWP
XI64_2 BL_33 BL__33 WL WL RA1SHCCP
XI65_0 BL_32 BL__32 VSS VSS VSS VSS RA1SHCCMWP
XI65_2 BL_32 BL__32 WL WL RA1SHCCP
XI66_0 BL_31 BL__31 VSS VSS VSS VSS RA1SHCCMWG
XI66_2 BL_31 BL__31 WL WL RA1SHCCG
XI68_0 BL_30 BL__30 VSS VSS VSS VSS RA1SHCCMWG
XI68_2 BL_30 BL__30 WL WL RA1SHCCG
XI69_0 BL_29 BL__29 VSS VSS VSS VSS RA1SHCCMWP
XI69_2 BL_29 BL__29 WL WL RA1SHCCP
XI6_0 BL_86 BL__86 MWLB MWLB MWPB MWPT RA1SHCCMWP
XI6_2 BL_86 BL__86 WL WL RA1SHCCP
XI70_0 BL_28 BL__28 VSS VSS VSS VSS RA1SHCCMWP
XI70_2 BL_28 BL__28 WL WL RA1SHCCP
XI71_0 BL_27 BL__27 VSS VSS VSS VSS RA1SHCCMWG
XI71_2 BL_27 BL__27 WL WL RA1SHCCG
XI72_0 BL_26 BL__26 VSS VSS VSS VSS RA1SHCCMWG
XI72_2 BL_26 BL__26 WL WL RA1SHCCG
XI73_0 BL_25 BL__25 VSS VSS VSS VSS RA1SHCCMWP
XI73_2 BL_25 BL__25 WL WL RA1SHCCP
XI74_0 BL_24 BL__24 VSS VSS VSS VSS RA1SHCCMWP
XI74_2 BL_24 BL__24 WL WL RA1SHCCP
XI75_0 BL_23 BL__23 VSS VSS VSS VSS RA1SHCCMWG
XI75_2 BL_23 BL__23 WL WL RA1SHCCG
XI76_0 BL_22 BL__22 VSS VSS VSS VSS RA1SHCCMWG
XI76_2 BL_22 BL__22 WL WL RA1SHCCG
XI77_0 BL_21 BL__21 VSS VSS VSS VSS RA1SHCCMWP
XI77_2 BL_21 BL__21 WL WL RA1SHCCP
XI78_0 BL_20 BL__20 VSS VSS VSS VSS RA1SHCCMWP
XI78_2 BL_20 BL__20 WL WL RA1SHCCP
XI79_0 BL_19 BL__19 VSS VSS VSS VSS RA1SHCCMWG
XI79_2 BL_19 BL__19 WL WL RA1SHCCG
XI7_0 BL_85 BL__85 MWLB MWLB MWPB MWPT RA1SHCCMWG
XI7_2 BL_85 BL__85 WL WL RA1SHCCG
XI80_0 BL_18 BL__18 VSS VSS VSS VSS RA1SHCCMWG
XI80_2 BL_18 BL__18 WL WL RA1SHCCG
XI81_0 BL_17 BL__17 VSS VSS VSS VSS RA1SHCCMWP
XI81_2 BL_17 BL__17 WL WL RA1SHCCP
XI82_0 BL_16 BL__16 VSS VSS VSS VSS RA1SHCCMWP
XI82_2 BL_16 BL__16 WL WL RA1SHCCP
XI83_0 BL_15 BL__15 VSS VSS VSS VSS RA1SHCCMWG
XI83_2 BL_15 BL__15 WL WL RA1SHCCG
XI85_0 BL_14 BL__14 VSS VSS VSS VSS RA1SHCCMWG
XI85_2 BL_14 BL__14 WL WL RA1SHCCG
XI86_0 BL_13 BL__13 VSS VSS VSS VSS RA1SHCCMWP
XI86_2 BL_13 BL__13 WL WL RA1SHCCP
XI87_0 BL_12 BL__12 VSS VSS VSS VSS RA1SHCCMWP
XI87_2 BL_12 BL__12 WL WL RA1SHCCP
XI88_0 BL_11 BL__11 VSS VSS VSS VSS RA1SHCCMWG
XI88_2 BL_11 BL__11 WL WL RA1SHCCG
XI89_0 BL_10 BL__10 VSS VSS VSS VSS RA1SHCCMWG
XI89_2 BL_10 BL__10 WL WL RA1SHCCG
XI8_0 BL_84 BL__84 MWLB MWLB MWPB MWPT RA1SHCCMWG
XI8_2 BL_84 BL__84 WL WL RA1SHCCG
XI90_0 BL_9 BL__9 VSS VSS VSS VSS RA1SHCCMWP
XI90_2 BL_9 BL__9 WL WL RA1SHCCP
XI91_0 BL_8 BL__8 VSS VSS VSS VSS RA1SHCCMWP
XI91_2 BL_8 BL__8 WL WL RA1SHCCP
XI92_0 BL_7 BL__7 VSS VSS VSS VSS RA1SHCCMWG
XI92_2 BL_7 BL__7 WL WL RA1SHCCG
XI93_0 BL_6 BL__6 VSS VSS VSS VSS RA1SHCCMWG
XI93_2 BL_6 BL__6 WL WL RA1SHCCG
XI94_0 BL_5 BL__5 VSS VSS VSS VSS RA1SHCCMWP
XI94_2 BL_5 BL__5 WL WL RA1SHCCP
XI95_0 BL_4 BL__4 VSS VSS VSS VSS RA1SHCCMWP
XI95_2 BL_4 BL__4 WL WL RA1SHCCP
XI96_0 BL_3 BL__3 VSS VSS VSS VSS RA1SHCCMWG
XI96_2 BL_3 BL__3 WL WL RA1SHCCG
XI97_0 BL_2 BL__2 VSS VSS VSS VSS RA1SHCCMWG
XI97_2 BL_2 BL__2 WL WL RA1SHCCG
XI98_0 BL_1 BL__1 VSS VSS VSS VSS RA1SHCCMWP
XI98_2 BL_1 BL__1 WL WL RA1SHCCP
XI99_0 BL_0 BL__0 VSS VSS VSS VSS RA1SHCCMWP
XI99_2 BL_0 BL__0 WL WL RA1SHCCP
XI9_0 BL_83 BL__83 MWLB MWLB MWPB MWPT RA1SHCCMWP
XI9_2 BL_83 BL__83 WL WL RA1SHCCP
.ENDS RA1SHMODEL_ROW_6
****
.SUBCKT RA1SHHWDB G0 G1 G2_W0 G2_W1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7
** RA1SHHWDB: 30 flat devices **
m1 N25 WD_I0-RSWN0 GTP VDD P L=0.18U W=2.3U
m10 WL0 WD_I0-WL0_EN_ VSS VSS N L=0.18U W=12.78U
m11 N24 WD_I0-RSWN1 GTP VDD P L=0.18U W=2.3U
m12 N24 WD_I0-WLI1 GTP VSS N L=0.18U W=2.3U
m13 N33 G0 VSS VSS N L=0.18U W=1.92U
m14 N34 G1 N33 VSS N L=0.18U W=1.92U
m15 WD_I0-RSWN1 G2_W1 N34 VSS N L=0.18U W=1.92U
m16 WD_I0-RSWN1 G0 VDD VDD P L=0.18U W=1.54U
m17 WD_I0-RSWN1 G2_W1 VDD VDD P L=0.18U W=1.54U
m18 WD_I0-RSWN1 G1 VDD VDD P L=0.18U W=1.54U
m19 WL1 WD_I0-WL1_EN_ VDD VDD P L=0.18U W=37.76U
m2 N25 WD_I0-WLI0 GTP VSS N L=0.18U W=2.3U
m20 WL1 WD_I0-WL1_EN_ VSS VSS N L=0.18U W=12.78U
m21 WD_I0-WLI1 WD_I0-RSWN1 VDD VDD P L=0.18U W=0.7U
m22 WD_I0-WLI1 WD_I0-RSWN1 VSS VSS N L=0.18U W=0.32U
m23 WD_I0-WLI0 WD_I0-RSWN0 VDD VDD P L=0.18U W=0.7U
m24 WD_I0-WLI0 WD_I0-RSWN0 VSS VSS N L=0.18U W=0.32U
m25 N24 WD_I0-RSWN1 VSS VSS N L=0.18U W=2.3U
m26 N25 WD_I0-RSWN0 VSS VSS N L=0.18U W=2.3U
m27 WD_I0-WL1_EN_ N24 VDD VDD P L=0.18U W=15.88U
m28 WD_I0-WL1_EN_ N24 VSS VSS N L=0.18U W=7.22U
m29 WD_I0-WL0_EN_ N25 VDD VDD P L=0.18U W=15.88U
m3 N26 G0 VSS VSS N L=0.18U W=1.92U
m30 WD_I0-WL0_EN_ N25 VSS VSS N L=0.18U W=7.22U
m4 N27 G1 N26 VSS N L=0.18U W=1.92U
m5 WD_I0-RSWN0 G2_W0 N27 VSS N L=0.18U W=1.92U
m6 WD_I0-RSWN0 G0 VDD VDD P L=0.18U W=1.54U
m7 WD_I0-RSWN0 G2_W0 VDD VDD P L=0.18U W=1.54U
m8 WD_I0-RSWN0 G1 VDD VDD P L=0.18U W=1.54U
m9 WL0 WD_I0-WL0_EN_ VDD VDD P L=0.18U W=37.76U
.ENDS RA1SHHWDB
****
.SUBCKT RA1SHHWDB0 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7
** RA1SHHWDB0: 30 flat devices **
XI0_0 G0 G1 XP2_0 XP2_1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 RA1SHHWDB
.ENDS RA1SHHWDB0
****
.SUBCKT RA1SHROW_BOTTOM G0 G1 GTP WL0 WL1 XP0 XP0_0 XP1 XP1_0 XP2_0 XP2_1
+  XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7
** RA1SHROW_BOTTOM: 30 flat devices **
XI2_0 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7
+  RA1SHHWDB0
.ENDS RA1SHROW_BOTTOM
****
.SUBCKT RA1SHWD G0 G1 G2_W0 G2_W1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7
** RA1SHWD: 30 flat devices **
m1 N25 RSWN0 GTP VDD P L=0.18U W=2.3U
m10 WL0 WL0_EN_ VSS VSS N L=0.18U W=12.78U
m11 N24 RSWN1 GTP VDD P L=0.18U W=2.3U
m12 N24 WLI1 GTP VSS N L=0.18U W=2.3U
m13 N33 G0 VSS VSS N L=0.18U W=1.92U
m14 N34 G1 N33 VSS N L=0.18U W=1.92U
m15 RSWN1 G2_W1 N34 VSS N L=0.18U W=1.92U
m16 RSWN1 G0 VDD VDD P L=0.18U W=1.54U
m17 RSWN1 G2_W1 VDD VDD P L=0.18U W=1.54U
m18 RSWN1 G1 VDD VDD P L=0.18U W=1.54U
m19 WL1 WL1_EN_ VDD VDD P L=0.18U W=37.76U
m2 N25 WLI0 GTP VSS N L=0.18U W=2.3U
m20 WL1 WL1_EN_ VSS VSS N L=0.18U W=12.78U
m21 WLI1 RSWN1 VDD VDD P L=0.18U W=0.7U
m22 WLI1 RSWN1 VSS VSS N L=0.18U W=0.32U
m23 WLI0 RSWN0 VDD VDD P L=0.18U W=0.7U
m24 WLI0 RSWN0 VSS VSS N L=0.18U W=0.32U
m25 N24 RSWN1 VSS VSS N L=0.18U W=2.3U
m26 N25 RSWN0 VSS VSS N L=0.18U W=2.3U
m27 WL1_EN_ N24 VDD VDD P L=0.18U W=15.88U
m28 WL1_EN_ N24 VSS VSS N L=0.18U W=7.22U
m29 WL0_EN_ N25 VDD VDD P L=0.18U W=15.88U
m3 N26 G0 VSS VSS N L=0.18U W=1.92U
m30 WL0_EN_ N25 VSS VSS N L=0.18U W=7.22U
m4 N27 G1 N26 VSS N L=0.18U W=1.92U
m5 RSWN0 G2_W0 N27 VSS N L=0.18U W=1.92U
m6 RSWN0 G0 VDD VDD P L=0.18U W=1.54U
m7 RSWN0 G2_W0 VDD VDD P L=0.18U W=1.54U
m8 RSWN0 G1 VDD VDD P L=0.18U W=1.54U
m9 WL0 WL0_EN_ VDD VDD P L=0.18U W=37.76U
.ENDS RA1SHWD
****
.SUBCKT RA1SHWD1 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7
** RA1SHWD1: 30 flat devices **
XI0_0 G0 G1 XP2_3 XP2_2 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 RA1SHWD
.ENDS RA1SHWD1
****
.SUBCKT RA1SHROW_FILLER1 G0 G1 GTP WL0 WL1 XP0 XP0F XP1 XP1F XP2_0 XP2_1 XP2_2
+  XP2_3 XP2_4 XP2_5 XP2_6 XP2_7
** RA1SHROW_FILLER1: 30 flat devices **
XI2_0 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7
+  RA1SHWD1
.ENDS RA1SHROW_FILLER1
****
.SUBCKT RA1SHWD2 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7
** RA1SHWD2: 30 flat devices **
XI0_0 G0 G1 XP2_4 XP2_5 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 RA1SHWD
.ENDS RA1SHWD2
****
.SUBCKT RA1SHROW_FILLER2 G0 G1 GTP WL0 WL1 XP0 XP0F XP1 XP1F XP2_0 XP2_1 XP2_2
+  XP2_3 XP2_4 XP2_5 XP2_6 XP2_7
** RA1SHROW_FILLER2: 30 flat devices **
XI2_0 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7
+  RA1SHWD2
.ENDS RA1SHROW_FILLER2
****
.SUBCKT RA1SHWD3 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7
** RA1SHWD3: 30 flat devices **
XI0_0 G0 G1 XP2_7 XP2_6 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 RA1SHWD
.ENDS RA1SHWD3
****
.SUBCKT RA1SHROW_FILLER3 G0 G1 GTP WL0 WL1 XP0 XP0F XP1 XP1F XP2_0 XP2_1 XP2_2
+  XP2_3 XP2_4 XP2_5 XP2_6 XP2_7
** RA1SHROW_FILLER3: 30 flat devices **
XI2_0 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7
+  RA1SHWD3
.ENDS RA1SHROW_FILLER3
****
.SUBCKT RA1SHWD0 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7
** RA1SHWD0: 30 flat devices **
XI0_0 G0 G1 XP2_0 XP2_1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 RA1SHWD
.ENDS RA1SHWD0
****
.SUBCKT RA1SHROW_8 G0 G1 G1B GTP WL0 WL1 XP0F XP0F_0 XP1F XP1F_0 XP2_0 XP2_1
+  XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7
** RA1SHROW_8: 30 flat devices **
XI2_0 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7
+  RA1SHWD0
.ENDS RA1SHROW_8
****
.SUBCKT RA1SHMWD GTP MBL MBL_ MWL XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7
** RA1SHMWD: 9 flat devices **
m1 MWL N16 VDD VDD P L=0.18U W=37.76U
m2 MWL N16 VSS VSS N L=0.18U W=12.78U
m3 N16 N15 VDD VDD P L=0.18U W=18.38U
m4 N16 N15 VSS VSS N L=0.18U W=5U
m5 MBL GTP VDD VDD P L=0.18U W=14.12U
m6 MBL_ GTP VDD VDD P L=0.18U W=14.12U
m7 MBL GTP MBL_ VDD P L=0.18U W=14.12U
m8 N15 VSS GTP VDD P L=0.5U W=4.4U
m9 N15 VDD GTP VSS N L=0.5U W=4.4U
.ENDS RA1SHMWD
****
.SUBCKT RA1SHROW_TOP G0F G1F GTP MBL MBL_ MWL XP0 XP0F XP1 XP1F XP2_0 XP2_1
+  XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7
** RA1SHROW_TOP: 9 flat devices **
XI2_0 GTP MBL MBL_ MWL XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7
+  RA1SHMWD
.ENDS RA1SHROW_TOP
****
.SUBCKT RA1SHWORD_ROWS G0 G1 GTP MBL MBL_ MWL WL0 WL0_0 WL0_1 WL0_2 WL0_3
+  WL0_4 WL0_5 WL0_6 WL0_7 WL0_8 WL0_9 WL0_10 WL0_11 WL0_12 WL0_13 WL0_14 WL1
+  WL1_0 WL1_1 WL1_2 WL1_3 WL1_4 WL1_5 WL1_6 WL1_7 WL1_8 WL1_9 WL1_10 WL1_11
+  WL1_12 WL1_13 WL1_14 XP0_0 XP1 XP1_0 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7
** RA1SHWORD_ROWS: 489 flat devices **
XI0_0 G0 G1 GTP WL0_14 WL1_14 G1 XP0_0 XP1 XP1_0 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 RA1SHROW_BOTTOM
XI0_1 G0 G1 GTP WL0_13 WL1_13 XP0_0 G1 XP1_0 XP1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 RA1SHROW_FILLER1
XI0_10 G0 XP0_0 GTP WL0_4 WL1_4 XP0_0 G1 XP1_0 XP1 XP2_0 XP2_1 XP2_2 XP2_3
+  XP2_4 XP2_5 XP2_6 XP2_7 RA1SHROW_FILLER2
XI0_11 G0 XP0_0 GTP WL0_3 WL1_3 XP0_0 G1 XP1_0 XP1 XP2_0 XP2_1 XP2_2 XP2_3
+  XP2_4 XP2_5 XP2_6 XP2_7 RA1SHROW_FILLER3
XI0_12 G0 XP1_0 XP0_0 GTP WL0_2 WL1_2 G1 XP0_0 XP1 XP1_0 XP2_0 XP2_1 XP2_2
+  XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 RA1SHROW_8
XI0_13 G0 XP1_0 GTP WL0_1 WL1_1 XP0_0 G1 XP1_0 XP1 XP2_0 XP2_1 XP2_2 XP2_3
+  XP2_4 XP2_5 XP2_6 XP2_7 RA1SHROW_FILLER1
XI0_14 G0 XP1_0 GTP WL0_0 WL1_0 XP0_0 G1 XP1_0 XP1 XP2_0 XP2_1 XP2_2 XP2_3
+  XP2_4 XP2_5 XP2_6 XP2_7 RA1SHROW_FILLER2
XI0_15 G0 XP1_0 GTP WL0 WL1 XP0_0 G1 XP1_0 XP1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 RA1SHROW_FILLER3
XI0_16 G0 XP1_0 GTP MBL MBL_ MWL XP0_0 G1 XP1_0 XP1 XP2_0 XP2_1 XP2_2 XP2_3
+  XP2_4 XP2_5 XP2_6 XP2_7 RA1SHROW_TOP
XI0_2 G0 G1 GTP WL0_12 WL1_12 XP0_0 G1 XP1_0 XP1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 RA1SHROW_FILLER2
XI0_3 G0 G1 GTP WL0_11 WL1_11 XP0_0 G1 XP1_0 XP1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 RA1SHROW_FILLER3
XI0_4 G0 XP1 G1 GTP WL0_10 WL1_10 G1 XP0_0 XP1 XP1_0 XP2_0 XP2_1 XP2_2 XP2_3
+  XP2_4 XP2_5 XP2_6 XP2_7 RA1SHROW_8
XI0_5 G0 XP1 GTP WL0_9 WL1_9 XP0_0 G1 XP1_0 XP1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 RA1SHROW_FILLER1
XI0_6 G0 XP1 GTP WL0_8 WL1_8 XP0_0 G1 XP1_0 XP1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 RA1SHROW_FILLER2
XI0_7 G0 XP1 GTP WL0_7 WL1_7 XP0_0 G1 XP1_0 XP1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 RA1SHROW_FILLER3
XI0_8 G0 XP0_0 XP1 GTP WL0_6 WL1_6 G1 XP0_0 XP1 XP1_0 XP2_0 XP2_1 XP2_2 XP2_3
+  XP2_4 XP2_5 XP2_6 XP2_7 RA1SHROW_8
XI0_9 G0 XP0_0 GTP WL0_5 WL1_5 XP0_0 G1 XP1_0 XP1 XP2_0 XP2_1 XP2_2 XP2_3
+  XP2_4 XP2_5 XP2_6 XP2_7 RA1SHROW_FILLER1
.ENDS RA1SHWORD_ROWS
****
.SUBCKT RA1SHHCKA A0 A0_ AGTP CLK GSRCN GTPN RST YP0_0 YP0_1 YP0_2 YP0_3 YP1_0
+  YP1_1 YP1_2 YP1_3
** RA1SHHCKA: 9 flat devices **
m1 CK-SRCFEED CK-GTPNSRC VSS VSS N L=0.18U W=41.46U
m2 GTPN CLK CK-GTPFEED VSS N L=0.18U W=13.82U
m3 GTPN RST VDD VDD P L=0.18U W=27.64U
m4 AGTP GTPN VDD VDD P L=0.18U W=66U
m5 AGTP GTPN VSS VSS N L=0.18U W=22U
m6 CK-GTPNSRC GSRCN VDD VDD P L=0.18U W=6.46U
m7 CK-GTPNSRC GSRCN VSS VSS N L=0.18U W=3.54U
m8 CK-GTPFEED CLK CK-SRCFEED VSS N L=0.18U W=13.82U
m9 CK-GTPFEED GTPN VDD VSS N L=0.18U W=3.44U
.ENDS RA1SHHCKA
****
.SUBCKT RA1SHCKP A0 A0_ CLK GSRCN GTP GTPN RST YP0_0 YP0_1 YP0_2 YP0_3 YP1_0
+  YP1_1 YP1_2 YP1_3
** RA1SHCKP: 3 flat devices **
m1 GTPN RST VDD VDD P L=0.18U W=27.64U
m2 GTP GTPN VDD VDD P L=0.18U W=66U
m3 GTP GTPN VSS VSS N L=0.18U W=22U
.ENDS RA1SHCKP
****
.SUBCKT RA1SHCK A0 A0_ CLK GSRCN GTP GTPN RST YP0_0 YP0_1 YP0_2 YP0_3 YP1_0
+  YP1_1 YP1_2 YP1_3
** RA1SHCK: 9 flat devices **
m1 SRCFEED GTPNSRC VSS VSS N L=0.18U W=41.46U
m2 GTPN CLK GTPFEED VSS N L=0.18U W=13.82U
m3 GTPN RST VDD VDD P L=0.18U W=27.64U
m4 GTP GTPN VDD VDD P L=0.18U W=66U
m5 GTP GTPN VSS VSS N L=0.18U W=22U
m6 GTPNSRC GSRCN VDD VDD P L=0.18U W=6.46U
m7 GTPNSRC GSRCN VSS VSS N L=0.18U W=3.54U
m8 GTPFEED CLK SRCFEED VSS N L=0.18U W=13.82U
m9 GTPFEED GTPN VDD VSS N L=0.18U W=3.44U
.ENDS RA1SHCK
****
.SUBCKT RA1SHCLK_DRVS A0 A0_ AGTP CLK GSRCN GTP GTPN GTP_0 GTP_1 GTP_2 RST
+  YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3
** RA1SHCLK_DRVS: 33 flat devices **
XI0_0 A0 A0_ AGTP CLK GSRCN GTPN RST YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2
+  YP1_3 RA1SHHCKA
XI1_0 A0 A0_ CLK GSRCN GTP_2 GTPN RST YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 RA1SHCKP
XI2_0 A0 A0_ CLK GSRCN GTP_1 GTPN RST YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 RA1SHCKP
XI3_0 A0 A0_ CLK GSRCN GTP_0 GTPN RST YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 RA1SHCK
XI4_0 A0 A0_ CLK GSRCN GTP GTPN RST YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2
+  YP1_3 RA1SHCK
.ENDS RA1SHCLK_DRVS
****
.SUBCKT RA1SHMUX_CD_EVEN A0 A0_ BL0 BL0_ BL0_0 BL0_1 BL0_2 BL0_3 BL0_4 BL0_5
+  BL0_6 BL0__0 BL0__1 BL0__2 BL0__3 BL0__4 BL0__5 BL0__6 BL1 BL1_ BL1_0 BL1_1
+  BL1_2 BL1_3 BL1_4 BL1_5 BL1_6 BL1__0 BL1__1 BL1__2 BL1__3 BL1__4 BL1__5
+  BL1__6 DRSA DRSA_0 DRSA_1 DRSA_2 DRSA_3 DRSA_4 DRSA_5 DRSA_6 DWSA DWSA_0
+  DWSA_1 DWSA_2 DWSA_3 DWSA_4 DWSA_5 DWSA_6 GTP STUBDR STUBDR_ STUBDW STUBDW_
+  YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3
** RA1SHMUX_CD_EVEN: 344 flat devices **
XI0_0 A0 A0_ BL0_6 BL0__6 BL1_6 BL1__6 DRSA_6 DWSA_6 YP0_0 VDD GTP DRSA_1
+  DRSA_0 DWSA_1 DWSA_0 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3
+  RA1SHCDX
XI1_0 A0 A0_ BL0_5 BL0__5 BL1_5 BL1__5 DRSA_5 DWSA_5 YP0_1 VDD GTP DRSA_1
+  DRSA_0 DWSA_1 DWSA_0 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3
+  RA1SHCDX
XI2_0 A0 A0_ BL0_4 BL0__4 BL1_4 BL1__4 DRSA_4 DWSA_4 YP0_2 VDD GTP DRSA_1
+  DRSA_0 DWSA_1 DWSA_0 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3
+  RA1SHCDX
XI3_0 A0 A0_ BL0_3 BL0__3 BL1_3 BL1__3 DRSA_3 DWSA_3 YP0_3 VDD GTP DRSA_1
+  DRSA_0 DWSA_1 DWSA_0 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3
+  RA1SHCDX
XI4_0 A0 A0_ BL0_2 BL0__2 BL1_2 BL1__2 DRSA_2 DWSA_2 VDD YP1_0 GTP DRSA_1
+  DRSA_0 DWSA_1 DWSA_0 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3
+  RA1SHCDX
XI5_0 A0 A0_ BL0_1 BL0__1 BL1_1 BL1__1 DRSA_1 DWSA_1 VDD YP1_1 GTP DRSA_1
+  DRSA_0 DWSA_1 DWSA_0 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3
+  RA1SHCDX
XI6_0 A0 A0_ BL0_0 BL0__0 BL1_0 BL1__0 DRSA_0 DWSA_0 VDD YP1_2 GTP DRSA_1
+  DRSA_0 DWSA_1 DWSA_0 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3
+  RA1SHCDX
XI7_0 A0 A0_ BL0 BL0_ BL1 BL1_ DRSA_1 DRSA DRSA_0 DWSA_1 DWSA DWSA_0 VDD YP1_3
+  GTP STUBDR STUBDR_ STUBDW STUBDW_ YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2
+  YP1_3 RA1SHCD
.ENDS RA1SHMUX_CD_EVEN
****
.SUBCKT RA1SHMXCOL_EVEN_RIGHT A0 A0_ BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6
+  BL_7 BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 D GTP
+  GTP_0 GTP_1 OE_ Q QI STUBDR STUBDR_ STUBDR_0 STUBDR__0 STUBDW STUBDW_
+  STUBDW_0 STUBDW__0 WE WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21
+  WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WP WP_0 WP_1 WP_2
+  WP_3 WP_4 WP_5 WP_6 WP_7 WP_8 WP_9 WP_10 WP_11 WP_12 WP_13 WP_14 WP_15
+  WP_16 WP_17 WP_18 WP_19 WP_20 WP_21 WP_22 WP_23 WP_24 WP_25 WP_26 WP_27
+  WP_28 WP_29 WP_30 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3
** RA1SHMXCOL_EVEN_RIGHT: 3520 flat devices **
XI0_0 OE_ GTP_1 WE RA1SHFLIO
XI0_1 GTP_0 RA1SHFLSA
XI0_2 A0 A0_ BL BL_ BL__2 BL_3 BL__6 BL_7 BL__10 BL_11 BL__14 BL_2 BL__3 BL_6
+  BL__7 BL_10 BL__11 BL_14 BL__0 BL_0 BL_1 BL__4 BL_5 BL__8 BL_9 BL__12 BL_13
+  BL__1 BL_4 BL__5 BL_8 BL__9 BL_12 BL__13 VSS STUBDR__0 STUBDR_0 VSS VSS VSS
+  VSS VSS VSS STUBDW__0 STUBDW_0 VSS VSS VSS VSS VSS GTP STUBDR STUBDR_
+  STUBDW STUBDW_ YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3
+  RA1SHMUX_CD_EVEN
XI0_3 BL BL_ BL_0 BL__0 BL_1 BL__1 BL_2 BL__2 BL_3 BL__3 BL_4 BL__4 BL_5 BL__5
+  BL_6 BL__6 BL_7 BL__7 BL_8 BL__8 BL_9 BL__9 BL_10 BL__10 BL_11 BL__11 BL_12
+  BL__12 BL_13 BL__13 BL_14 BL__14 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WP WP_0 WP_1
+  WP_2 WP_3 WP_4 WP_5 WP_6 WP_7 WP_8 WP_9 WP_10 WP_11 WP_12 WP_13 WP_14 WP_15
+  WP_16 WP_17 WP_18 WP_19 WP_20 WP_21 WP_22 WP_23 WP_24 WP_25 WP_26 WP_27
+  WP_28 WP_29 WP_30 RA1SHBIT_COL
XI1_0 D DI_ DPN DPU STUBDW_0 STUBDW__0 GTP_1 IO IO_1 OE_ Q QI SP WE RA1SHIOX
XI1_1 DPN DPU STUBDR_0 STUBDR__0 STUBDW_0 STUBDW__0 GTP_0 SP RA1SHSA8
.ENDS RA1SHMXCOL_EVEN_RIGHT
****
.SUBCKT RA1SHCOLS_1_RIGHT A0 A0_ BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6
+  BL_7 BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 D DR DR_
+  DW DW_ GTP GTP_0 GTP_1 OE_ Q QI STUBDR STUBDR_ STUBDW STUBDW_ WE WL WL_0
+  WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14
+  WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26
+  WL_27 WL_28 WL_29 WL_30 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3
** RA1SHCOLS_1_RIGHT: 3520 flat devices **
XI0_0 A0 A0_ BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10
+  BL_11 BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 D GTP GTP_0 GTP_1 OE_ Q QI
+  DR DR_ STUBDR STUBDR_ DW DW_ STUBDW STUBDW_ WE WL WL_0 WL_1 WL_2 WL_3 WL_4
+  WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17
+  WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29
+  WL_30 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0
+  YP1_1 YP1_2 YP1_3 RA1SHMXCOL_EVEN_RIGHT
.ENDS RA1SHCOLS_1_RIGHT
****
.SUBCKT RA1SHCOLS_NS_1_RIGHT A0 A0_ BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6
+  BL_7 BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 D GTP
+  GTP_0 GTP_1 OE_ Q QI STUBDR STUBDR_ STUBDR_0 STUBDR__0 STUBDW STUBDW_
+  STUBDW_0 STUBDW__0 WE WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21
+  WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WP WP_0 WP_1 WP_2
+  WP_3 WP_4 WP_5 WP_6 WP_7 WP_8 WP_9 WP_10 WP_11 WP_12 WP_13 WP_14 WP_15
+  WP_16 WP_17 WP_18 WP_19 WP_20 WP_21 WP_22 WP_23 WP_24 WP_25 WP_26 WP_27
+  WP_28 WP_29 WP_30 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3
** RA1SHCOLS_NS_1_RIGHT: 3520 flat devices **
XI0_0 A0 A0_ BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10
+  BL_11 BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 D GTP GTP_0 GTP_1 OE_ Q QI
+  STUBDR STUBDR_ STUBDR_0 STUBDR__0 STUBDW STUBDW_ STUBDW_0 STUBDW__0 WE WL
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WP WP_0 WP_1 WP_2 WP_3 WP_4 WP_5 WP_6 WP_7
+  WP_8 WP_9 WP_10 WP_11 WP_12 WP_13 WP_14 WP_15 WP_16 WP_17 WP_18 WP_19 WP_20
+  WP_21 WP_22 WP_23 WP_24 WP_25 WP_26 WP_27 WP_28 WP_29 WP_30 YP0_0 YP0_1
+  YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 RA1SHMXCOL_EVEN_RIGHT
.ENDS RA1SHCOLS_NS_1_RIGHT
****
.SUBCKT RA1SHWING_6_RIGHT A0 A0_ BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6
+  BL_7 BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19
+  BL_20 BL_21 BL_22 BL_23 BL_24 BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31
+  BL_32 BL_33 BL_34 BL_35 BL_36 BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43
+  BL_44 BL_45 BL_46 BL_47 BL_48 BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55
+  BL_56 BL_57 BL_58 BL_59 BL_60 BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67
+  BL_68 BL_69 BL_70 BL_71 BL_72 BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79
+  BL_80 BL_81 BL_82 BL_83 BL_84 BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91
+  BL_92 BL_93 BL_94 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19
+  BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29
+  BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39
+  BL__40 BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49
+  BL__50 BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59
+  BL__60 BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69
+  BL__70 BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79
+  BL__80 BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89
+  BL__90 BL__91 BL__92 BL__93 BL__94 D D_0 D_1 D_2 D_3 D_4 GTP GTP_0 GTP_1
+  OE_ Q QI QI_0 QI_1 QI_2 QI_3 QI_4 Q_0 Q_1 Q_2 Q_3 Q_4 STUBDR STUBDR_
+  STUBDR_0 STUBDR__0 STUBDW STUBDW_ STUBDW_0 STUBDW__0 WE WL WL_0 WL_1 WL_2
+  WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15
+  WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27
+  WL_28 WL_29 WL_30 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3
** RA1SHWING_6_RIGHT: 21120 flat devices **
XI0_0 A0 A0_ BL_79 BL__79 BL_80 BL_81 BL_82 BL_83 BL_84 BL_85 BL_86 BL_87
+  BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL__80 BL__81 BL__82 BL__83
+  BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90 BL__91 BL__92 BL__93
+  BL__94 D_4 DR DR_ DW DW_ GTP GTP_0 GTP_1 OE_ Q_4 QI_4 STUBDR_0 STUBDR__0
+  STUBDW_0 STUBDW__0 WE WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21
+  WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 YP0_0 YP0_1 YP0_2
+  YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 RA1SHCOLS_1_RIGHT
XI1_0 A0 A0_ BL_63 BL__63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71
+  BL_72 BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL__64 BL__65 BL__66 BL__67
+  BL__68 BL__69 BL__70 BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77
+  BL__78 D_3 DR_6 DR__4 DW_8 DW__10 GTP GTP_0 GTP_1 OE_ Q_3 QI_3 DR DR_ DW
+  DW_ WE WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0
+  YP1_1 YP1_2 YP1_3 RA1SHCOLS_1_RIGHT
XI2_0 A0 A0_ BL_47 BL__47 BL_48 BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55
+  BL_56 BL_57 BL_58 BL_59 BL_60 BL_61 BL_62 BL__48 BL__49 BL__50 BL__51
+  BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60 BL__61
+  BL__62 D_2 DR_14 DR__12 DW_16 DW__18 GTP GTP_0 GTP_1 OE_ Q_2 QI_2 DR_6
+  DR__4 DW_8 DW__10 WE WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21
+  WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 YP0_0 YP0_1 YP0_2
+  YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 RA1SHCOLS_1_RIGHT
XI3_0 A0 A0_ BL_31 BL__31 BL_32 BL_33 BL_34 BL_35 BL_36 BL_37 BL_38 BL_39
+  BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL__32 BL__33 BL__34 BL__35
+  BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 BL__44 BL__45
+  BL__46 D_1 DR_22 DR__20 DW_24 DW__26 GTP GTP_0 GTP_1 OE_ Q_1 QI_1 DR_14
+  DR__12 DW_16 DW__18 WE WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21
+  WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 YP0_0 YP0_1 YP0_2
+  YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 RA1SHCOLS_1_RIGHT
XI4_0 A0 A0_ BL_15 BL__15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23
+  BL_24 BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL__16 BL__17 BL__18 BL__19
+  BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29
+  BL__30 D_0 DR_30 DR__28 DW_32 DW__34 GTP GTP_0 GTP_1 OE_ Q_0 QI_0 DR_22
+  DR__20 DW_24 DW__26 WE WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21
+  WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 YP0_0 YP0_1 YP0_2
+  YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 RA1SHCOLS_1_RIGHT
XI5_0 A0 A0_ BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10
+  BL_11 BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 D GTP GTP_0 GTP_1 OE_ Q QI
+  STUBDR STUBDR_ DR_30 DR__28 STUBDW STUBDW_ DW_32 DW__34 WE WL WL_0 WL_1
+  WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15
+  WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27
+  WL_28 WL_29 WL_30 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21
+  WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 YP0_0 YP0_1 YP0_2
+  YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 RA1SHCOLS_NS_1_RIGHT
.ENDS RA1SHWING_6_RIGHT
****
.SUBCKT RA1SHRIGHT_CAP A0 A0_ GTP GTP_0 GTP_1 OE_ WE WL WL_0 WL_1 WL_2 WL_3
+  WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16
+  WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28
+  WL_29 WL_30 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3
** RA1SHRIGHT_CAP: 206 flat devices **
XI0_10 VDD VDD WL_23 WL_23 RA1SHCCG
XI0_11 VDD VDD WL_22 WL_22 RA1SHCCG
XI0_12 VDD VDD WL_21 WL_21 RA1SHCCG
XI0_13 VDD VDD WL_20 WL_20 RA1SHCCG
XI0_14 VDD VDD WL_19 WL_19 RA1SHCCG
XI0_15 VDD VDD WL_18 WL_18 RA1SHCCG
XI0_16 VDD VDD WL_17 WL_17 RA1SHCCG
XI0_17 VDD VDD WL_16 WL_16 RA1SHCCG
XI0_18 VDD VDD WL_15 WL_15 RA1SHCCG
XI0_19 VDD VDD WL_14 WL_14 RA1SHCCG
XI0_20 VDD VDD WL_13 WL_13 RA1SHCCG
XI0_21 VDD VDD WL_12 WL_12 RA1SHCCG
XI0_22 VDD VDD WL_11 WL_11 RA1SHCCG
XI0_23 VDD VDD WL_10 WL_10 RA1SHCCG
XI0_24 VDD VDD WL_9 WL_9 RA1SHCCG
XI0_25 VDD VDD WL_8 WL_8 RA1SHCCG
XI0_26 VDD VDD WL_7 WL_7 RA1SHCCG
XI0_27 VDD VDD WL_6 WL_6 RA1SHCCG
XI0_28 VDD VDD WL_5 WL_5 RA1SHCCG
XI0_29 VDD VDD WL_4 WL_4 RA1SHCCG
XI0_3 VDD VDD WL_30 WL_30 RA1SHCCG
XI0_30 VDD VDD WL_3 WL_3 RA1SHCCG
XI0_31 VDD VDD WL_2 WL_2 RA1SHCCG
XI0_32 VDD VDD WL_1 WL_1 RA1SHCCG
XI0_33 VDD VDD WL_0 WL_0 RA1SHCCG
XI0_34 VDD VDD WL WL RA1SHCCG
XI0_35 VDD VDD VSS VSS VSS VSS RA1SHCCMWG
XI0_37 VDD VDD VSS VSS RA1SHCCG
XI0_4 VDD VDD WL_29 WL_29 RA1SHCCG
XI0_5 VDD VDD WL_28 WL_28 RA1SHCCG
XI0_6 VDD VDD WL_27 WL_27 RA1SHCCG
XI0_7 VDD VDD WL_26 WL_26 RA1SHCCG
XI0_8 VDD VDD WL_25 WL_25 RA1SHCCG
XI0_9 VDD VDD WL_24 WL_24 RA1SHCCG
.ENDS RA1SHRIGHT_CAP
****
.SUBCKT RA1SHCCMBT MBL MBL_ TIEDOWN WL
** RA1SHCCMBT: 6 flat devices **
m1 MBL TIEDOWN CORED VSS N L=0.235U W=0.21U
m2 MBL_ TIEDOWN CORED_ VSS N L=0.235U W=0.21U
m3 CORED_ CORED VDD VDD P L=0.18U W=0.22U
m4 CORED_ CORED VSS VSS N L=0.18U W=0.42U
m5 CORED CORED_ VDD VDD P L=0.18U W=0.22U
m6 CORED CORED_ VSS VSS N L=0.18U W=0.42U
.ENDS RA1SHCCMBT
****
.SUBCKT RA1SHCCMBB MBL MBL_ TIEDOWN WL
** RA1SHCCMBB: 6 flat devices **
m1 MBL TIEDOWN CORED VSS N L=0.235U W=0.21U
m2 MBL_ TIEDOWN CORED_ VSS N L=0.235U W=0.21U
m3 CORED_ CORED VDD VDD P L=0.18U W=0.22U
m4 CORED_ CORED VSS VSS N L=0.18U W=0.42U
m5 CORED CORED_ VDD VDD P L=0.18U W=0.22U
m6 CORED CORED_ VSS VSS N L=0.18U W=0.42U
.ENDS RA1SHCCMBB
****
.SUBCKT RA1SHCCPDBB GTP MBL MBL_ MWL TIEDOWN WL
** RA1SHCCPDBB: 3 flat devices **
m1 CORED GTP VSS VSS N L=0.18U W=0.42U
m2 MBL MWL CORED VSS N L=0.235U W=0.21U
m3 MBL_ MWL VDD VSS N L=0.235U W=0.21U
.ENDS RA1SHCCPDBB
****
.SUBCKT RA1SHCCPDT GTP MBL MBL_ MWL TIEDOWN WL
** RA1SHCCPDT: 3 flat devices **
m1 CORED_ GTP VSS VSS N L=0.18U W=0.42U
m2 MBL MWL VDD VSS N L=0.235U W=0.21U
m3 MBL_ MWL CORED_ VSS N L=0.235U W=0.21U
.ENDS RA1SHCCPDT
****
.SUBCKT RA1SHCCPDB GTP MBL MBL_ MWL TIEDOWN WL
** RA1SHCCPDB: 3 flat devices **
m1 CORED GTP VSS VSS N L=0.18U W=0.42U
m2 MBL MWL CORED VSS N L=0.235U W=0.21U
m3 MBL_ MWL VDD VSS N L=0.235U W=0.21U
.ENDS RA1SHCCPDB
****
.SUBCKT RA1SHMBLBASE GTP MBL MBL_ MWLD MWLS
** RA1SHMBLBASE: 12 flat devices **
m1 N13 GTP VSS VSS N L=0.18U W=0.42U
m10 MBL MWLD N17 VSS N L=0.235U W=0.21U
m11 N18 GTP VSS VSS N L=0.18U W=0.42U
m12 MBL MWLD N18 VSS N L=0.235U W=0.21U
m2 MBL MWLD N13 VSS N L=0.235U W=0.21U
m3 N14 GTP VSS VSS N L=0.18U W=0.42U
m4 MBL MWLD N14 VSS N L=0.235U W=0.21U
m5 N15 GTP VSS VSS N L=0.18U W=0.42U
m6 MBL MWLD N15 VSS N L=0.235U W=0.21U
m7 N16 GTP VSS VSS N L=0.18U W=0.42U
m8 MBL MWLD N16 VSS N L=0.235U W=0.21U
m9 N17 GTP VSS VSS N L=0.18U W=0.42U
.ENDS RA1SHMBLBASE
****
.SUBCKT RA1SHMODEL_COL GTP MBL MBL_ MWLD MWLS WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5
+  WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18
+  WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30
** RA1SHMODEL_COL: 186 flat devices **
XI0_0 MBL MBL_ VSS WL_30 RA1SHCCMBB
XI0_1 MBL_ MBL VSS WL_29 RA1SHCCMBT
XI0_10 MBL MBL_ VSS WL_20 RA1SHCCMBB
XI0_11 MBL_ MBL VSS WL_19 RA1SHCCMBT
XI0_12 MBL MBL_ VSS WL_18 RA1SHCCMBB
XI0_13 MBL_ MBL VSS WL_17 RA1SHCCMBT
XI0_14 MBL MBL_ VSS WL_16 RA1SHCCMBB
XI0_15 MBL_ MBL VSS WL_15 RA1SHCCMBT
XI0_16 MBL MBL_ VSS WL_14 RA1SHCCMBB
XI0_17 MBL_ MBL VSS WL_13 RA1SHCCMBT
XI0_18 MBL MBL_ VSS WL_12 RA1SHCCMBB
XI0_19 MBL_ MBL VSS WL_11 RA1SHCCMBT
XI0_2 MBL MBL_ VSS WL_28 RA1SHCCMBB
XI0_20 MBL MBL_ VSS WL_10 RA1SHCCMBB
XI0_21 MBL_ MBL VSS WL_9 RA1SHCCMBT
XI0_22 MBL MBL_ VSS WL_8 RA1SHCCMBB
XI0_23 MBL_ MBL VSS WL_7 RA1SHCCMBT
XI0_24 MBL MBL_ VSS WL_6 RA1SHCCMBB
XI0_25 MBL_ MBL VSS WL_5 RA1SHCCMBT
XI0_26 GTP MBL MBL_ MWLD VSS WL_4 RA1SHCCPDBB
XI0_27 GTP MBL_ MBL MWLD VSS WL_3 RA1SHCCPDT
XI0_28 GTP MBL MBL_ MWLD VSS WL_2 RA1SHCCPDB
XI0_29 GTP MBL_ MBL MWLD VSS WL_1 RA1SHCCPDT
XI0_3 MBL_ MBL VSS WL_27 RA1SHCCMBT
XI0_30 GTP MBL MBL_ MWLD VSS WL_0 RA1SHCCPDB
XI0_31 GTP MBL_ MBL MWLD VSS WL RA1SHCCPDT
XI0_32 GTP MBL MBL_ MWLD MWLS RA1SHMBLBASE
XI0_4 MBL MBL_ VSS WL_26 RA1SHCCMBB
XI0_5 MBL_ MBL VSS WL_25 RA1SHCCMBT
XI0_6 MBL MBL_ VSS WL_24 RA1SHCCMBB
XI0_7 MBL_ MBL VSS WL_23 RA1SHCCMBT
XI0_8 MBL MBL_ VSS WL_22 RA1SHCCMBB
XI0_9 MBL_ MBL VSS WL_21 RA1SHCCMBT
.ENDS RA1SHMODEL_COL
****
.SUBCKT RA1SH A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] A[8] CEN CLK D[0] D[1]
+  D[2] D[3] D[4] D[5] D[6] D[7] D[8] D[9] D[10] D[11] OEN Q[0] Q[1] Q[2] Q[3]
+  Q[4] Q[5] Q[6] Q[7] Q[8] Q[9] Q[10] Q[11] WEN
** RA1SH: 46646 flat devices **
XI0_0 A0 A0_ GTP GTP GTP OE_ STUBDR STUBDR_ STUBDW STUBDW_ WE WL WL_0 WL_1
+  WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15
+  WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27
+  WL_28 WL_29 WL_30 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3
+  RA1SHLEFT_CAP
XI1_0 A0 A0_ BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10
+  BL_11 BL_12 BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22
+  BL_23 BL_24 BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34
+  BL_35 BL_36 BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46
+  BL_47 BL_48 BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58
+  BL_59 BL_60 BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70
+  BL_71 BL_72 BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82
+  BL_83 BL_84 BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94
+  BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11
+  BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21
+  BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31
+  BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41
+  BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50 BL__51
+  BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60 BL__61
+  BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70 BL__71
+  BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80 BL__81
+  BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90 BL__91
+  BL__92 BL__93 BL__94 D[0] D[1] D[2] D[3] D[4] D[5] GTP GTP GTP OE_ Q[0]
+  QI_10 QI_9 QI_8 QI_7 QI_6 QI_5 Q[1] Q[2] Q[3] Q[4] Q[5] STUBDR_ STUBDR VSS
+  VSS STUBDW STUBDW_ VSS VSS WE WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 YP0_0 YP0_1
+  YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 RA1SHWING_6_LEFT
XI1_5 BL_ BL__46 BL_46 BL__45 BL_45 BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5
+  BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16
+  BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26
+  BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36
+  BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 BL__44 BL__47 BL__48
+  BL__49 BL__50 BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58
+  BL__59 BL__60 BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68
+  BL__69 BL__70 BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78
+  BL__79 BL__80 BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88
+  BL__89 BL__90 BL__91 BL__92 BL__93 BL__94 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5
+  BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 BL_16 BL_17 BL_18
+  BL_19 BL_20 BL_21 BL_22 BL_23 BL_24 BL_25 BL_26 BL_27 BL_28 BL_29 BL_30
+  BL_31 BL_32 BL_33 BL_34 BL_35 BL_36 BL_37 BL_38 BL_39 BL_40 BL_41 BL_42
+  BL_43 BL_44 BL_47 BL_48 BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56
+  BL_57 BL_58 BL_59 BL_60 BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68
+  BL_69 BL_70 BL_71 BL_72 BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80
+  BL_81 BL_82 BL_83 BL_84 BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92
+  BL_93 BL_94 MWLB MWLB MWLB VSS RA1SHMODEL_ROW_6
XI3_0 A[4] A[7] A[5] A[8] A[6] AGTPT AGTPT A0 A0_ OE_ WE XP_0 XP_0_0 XP_1
+  XP_1_0 XP_2 XP_2_0 XP_3 XP_3_0 XP_4 XP_5 XP_6 XP_7 YP0_0 YP0_1 YP0_2 YP0_3
+  YP1_0 YP1_1 YP1_2 YP1_3 RA1SHX_PRE_DECODE
XI3_3 VDD XP_0_0 GTP MBL MBL_ MWLB WL WL_2 WL_3 WL_6 WL_7 WL_10 WL_11 WL_14
+  WL_15 WL_18 WL_19 WL_22 WL_23 WL_26 WL_27 WL_30 WL_0 WL_1 WL_4 WL_5 WL_8
+  WL_9 WL_12 WL_13 WL_16 WL_17 WL_20 WL_21 WL_24 WL_25 WL_28 WL_29 XP_2_0
+  XP_1_0 XP_3_0 XP_0 XP_1 XP_2 XP_3 XP_4 XP_5 XP_6 XP_7 RA1SHWORD_ROWS
XI4_0 A[0] A[1] A[2] A[3] AGTPT A0 A0_ CLK GSRCN GTPN OE_ RST WE YP0_0 YP0_1
+  YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 RA1SHY_DECODE
XI5_0 CEN CENI_ CLK GSRCN GTP GTPN IO IO_1 IO_3 IO_5 IO_7 IO_9 IO_11 IO_16 MBL
+  OE_ OEN OENI_ RST WE WEN WENI_ RA1SHHBFX
XI5_2 A0 A0_ AGTPT CLK GSRCN GTP GTPN GTP GTP GTP RST YP0_0 YP0_1 YP0_2 YP0_3
+  YP1_0 YP1_1 YP1_2 YP1_3 RA1SHCLK_DRVS
XI6_4 GTP MBL MBL_ MWLB MWLB WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 RA1SHMODEL_COL
XI7_0 A0 A0_ BL_271 BL__273 BL_0_275 BL_1_279 BL_2_283 BL_3_287 BL_4_291
+  BL_5_295 BL_6_299 BL_7_303 BL_8_307 BL_9_311 BL_10_315 BL_11_319 BL_12_323
+  BL_13_327 BL_14_331 BL_15_335 BL_16_339 BL_17_343 BL_18_347 BL_19_351
+  BL_20_355 BL_21_359 BL_22_363 BL_23_367 BL_24_371 BL_25_375 BL_26_379
+  BL_27_383 BL_28_387 BL_29_391 BL_30_395 BL_31_399 BL_32_403 BL_33_407
+  BL_34_411 BL_35_415 BL_36_419 BL_37_423 BL_38_427 BL_39_431 BL_40_435
+  BL_41_439 BL_42_443 BL_43_447 BL_44_451 BL_45_455 BL_46_459 BL_47_463
+  BL_48_467 BL_49_471 BL_50_475 BL_51_479 BL_52_483 BL_53_487 BL_54_491
+  BL_55_495 BL_56_499 BL_57_503 BL_58_507 BL_59_511 BL_60_515 BL_61_519
+  BL_62_523 BL_63_527 BL_64_531 BL_65_535 BL_66_539 BL_67_543 BL_68_547
+  BL_69_551 BL_70_555 BL_71_559 BL_72_563 BL_73_567 BL_74_571 BL_75_575
+  BL_76_579 BL_77_583 BL_78_587 BL_79_591 BL_80_595 BL_81_599 BL_82_603
+  BL_83_607 BL_84_611 BL_85_615 BL_86_619 BL_87_623 BL_88_627 BL_89_631
+  BL_90_635 BL_91_639 BL_92_643 BL_93_647 BL_94_651 BL__0_277 BL__1_281
+  BL__2_285 BL__3_289 BL__4_293 BL__5_297 BL__6_301 BL__7_305 BL__8_309
+  BL__9_313 BL__10_317 BL__11_321 BL__12_325 BL__13_329 BL__14_333 BL__15_337
+  BL__16_341 BL__17_345 BL__18_349 BL__19_353 BL__20_357 BL__21_361
+  BL__22_365 BL__23_369 BL__24_373 BL__25_377 BL__26_381 BL__27_385
+  BL__28_389 BL__29_393 BL__30_397 BL__31_401 BL__32_405 BL__33_409
+  BL__34_413 BL__35_417 BL__36_421 BL__37_425 BL__38_429 BL__39_433
+  BL__40_437 BL__41_441 BL__42_445 BL__43_449 BL__44_453 BL__45_457
+  BL__46_461 BL__47_465 BL__48_469 BL__49_473 BL__50_477 BL__51_481
+  BL__52_485 BL__53_489 BL__54_493 BL__55_497 BL__56_501 BL__57_505
+  BL__58_509 BL__59_513 BL__60_517 BL__61_521 BL__62_525 BL__63_529
+  BL__64_533 BL__65_537 BL__66_541 BL__67_545 BL__68_549 BL__69_553
+  BL__70_557 BL__71_561 BL__72_565 BL__73_569 BL__74_573 BL__75_577
+  BL__76_581 BL__77_585 BL__78_589 BL__79_593 BL__80_597 BL__81_601
+  BL__82_605 BL__83_609 BL__84_613 BL__85_617 BL__86_621 BL__87_625
+  BL__88_629 BL__89_633 BL__90_637 BL__91_641 BL__92_645 BL__93_649
+  BL__94_653 D[11] D[10] D[9] D[8] D[7] D[6] GTP GTP GTP OE_ Q[11] QI QI_0
+  QI_1 QI_2 QI_3 QI_4 Q[10] Q[9] Q[8] Q[7] Q[6] VSS VSS STUBDR_0 STUBDR__0
+  VSS VSS STUBDW_0 STUBDW__0 WE WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 YP0_0 YP0_1
+  YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 RA1SHWING_6_RIGHT
XI7_5 BL__273 BL__46_461 BL_46_459 BL__45_457 BL_45_455 BL_271 BL__0_277
+  BL__1_281 BL__2_285 BL__3_289 BL__4_293 BL__5_297 BL__6_301 BL__7_305
+  BL__8_309 BL__9_313 BL__10_317 BL__11_321 BL__12_325 BL__13_329 BL__14_333
+  BL__15_337 BL__16_341 BL__17_345 BL__18_349 BL__19_353 BL__20_357
+  BL__21_361 BL__22_365 BL__23_369 BL__24_373 BL__25_377 BL__26_381
+  BL__27_385 BL__28_389 BL__29_393 BL__30_397 BL__31_401 BL__32_405
+  BL__33_409 BL__34_413 BL__35_417 BL__36_421 BL__37_425 BL__38_429
+  BL__39_433 BL__40_437 BL__41_441 BL__42_445 BL__43_449 BL__44_453
+  BL__47_465 BL__48_469 BL__49_473 BL__50_477 BL__51_481 BL__52_485
+  BL__53_489 BL__54_493 BL__55_497 BL__56_501 BL__57_505 BL__58_509
+  BL__59_513 BL__60_517 BL__61_521 BL__62_525 BL__63_529 BL__64_533
+  BL__65_537 BL__66_541 BL__67_545 BL__68_549 BL__69_553 BL__70_557
+  BL__71_561 BL__72_565 BL__73_569 BL__74_573 BL__75_577 BL__76_581
+  BL__77_585 BL__78_589 BL__79_593 BL__80_597 BL__81_601 BL__82_605
+  BL__83_609 BL__84_613 BL__85_617 BL__86_621 BL__87_625 BL__88_629
+  BL__89_633 BL__90_637 BL__91_641 BL__92_645 BL__93_649 BL__94_653 BL_0_275
+  BL_1_279 BL_2_283 BL_3_287 BL_4_291 BL_5_295 BL_6_299 BL_7_303 BL_8_307
+  BL_9_311 BL_10_315 BL_11_319 BL_12_323 BL_13_327 BL_14_331 BL_15_335
+  BL_16_339 BL_17_343 BL_18_347 BL_19_351 BL_20_355 BL_21_359 BL_22_363
+  BL_23_367 BL_24_371 BL_25_375 BL_26_379 BL_27_383 BL_28_387 BL_29_391
+  BL_30_395 BL_31_399 BL_32_403 BL_33_407 BL_34_411 BL_35_415 BL_36_419
+  BL_37_423 BL_38_427 BL_39_431 BL_40_435 BL_41_439 BL_42_443 BL_43_447
+  BL_44_451 BL_47_463 BL_48_467 BL_49_471 BL_50_475 BL_51_479 BL_52_483
+  BL_53_487 BL_54_491 BL_55_495 BL_56_499 BL_57_503 BL_58_507 BL_59_511
+  BL_60_515 BL_61_519 BL_62_523 BL_63_527 BL_64_531 BL_65_535 BL_66_539
+  BL_67_543 BL_68_547 BL_69_551 BL_70_555 BL_71_559 BL_72_563 BL_73_567
+  BL_74_571 BL_75_575 BL_76_579 BL_77_583 BL_78_587 BL_79_591 BL_80_595
+  BL_81_599 BL_82_603 BL_83_607 BL_84_611 BL_85_615 BL_86_619 BL_87_623
+  BL_88_627 BL_89_631 BL_90_635 BL_91_639 BL_92_643 BL_93_647 BL_94_651 MWLB
+  MWLB MWLB VSS RA1SHMODEL_ROW_6
XI8_0 A0 A0_ GTP GTP GTP OE_ WE WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 YP0_0 YP0_1
+  YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 RA1SHRIGHT_CAP
.ENDS RA1SH
